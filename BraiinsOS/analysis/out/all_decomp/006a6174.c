// FUN_006a6174 @ 006a6174 size=1848 calls_out=9 calls_in=1
// strings: assertion failed: DEFAULT_MAX_FRAME_SIZE <= val && val <= MAX_MAX_FRAME_SIZE:authority:method:scheme:path:protocol:statush2::proto::connection/nix/store/eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee-vendor-cargo-deps/c19b7c6f923b580ac259164a89f2577984ad5ab09ee9d583b888f934adbbe8d0/h2-0.4.7/src/proto/connection.rs

void FUN_006a6174(undefined4 *param_1,undefined4 *param_2,undefined4 param_3,undefined4 param_4,
                 undefined4 *param_5,undefined4 param_6,undefined4 param_7)

{
  byte bVar1;
  byte bVar2;
  undefined1 uVar3;
  char cVar4;
  int iVar5;
  undefined4 uVar6;
  undefined4 uVar7;
  undefined4 uVar8;
  int iVar9;
  undefined4 uVar10;
  undefined4 uVar11;
  undefined4 uVar12;
  undefined4 uVar13;
  int iVar14;
  uint uVar15;
  undefined4 uVar16;
  undefined4 uVar17;
  undefined4 uVar18;
  undefined4 uVar19;
  undefined4 uVar20;
  undefined4 uVar21;
  int iVar22;
  undefined4 uVar23;
  undefined4 uVar24;
  undefined4 uVar25;
  undefined4 local_948;
  undefined4 uStack_944;
  uint local_940;
  int local_93c;
  int local_938;
  undefined4 uStack_934;
  int iStack_930;
  undefined4 uStack_92c;
  undefined4 local_928;
  undefined4 local_924;
  undefined1 auStack_920 [232];
  undefined1 auStack_838 [216];
  int local_760;
  undefined1 auStack_75c [96];
  undefined4 local_6fc;
  uint local_6f8;
  undefined4 local_6f0;
  undefined4 local_6ec;
  uint local_6e8;
  int local_6e4;
  int local_6e0;
  undefined4 local_6dc;
  int local_6d8;
  undefined4 local_6d4;
  undefined4 local_6d0;
  undefined4 local_6cc;
  int local_6c8;
  undefined4 local_6c4;
  undefined4 local_6c0;
  uint local_6bc;
  undefined4 local_6b8;
  undefined1 local_6b4;
  undefined4 local_698;
  undefined4 local_660;
  int local_628 [102];
  undefined4 local_490;
  undefined4 local_48c;
  int local_488;
  undefined4 uStack_484;
  undefined4 local_480;
  undefined4 uStack_47c;
  undefined4 uStack_478;
  undefined4 uStack_474;
  undefined4 local_258;
  undefined4 uStack_254;
  undefined4 uStack_250;
  undefined4 uStack_24c;
  undefined4 uStack_248;
  undefined4 uStack_244;
  int iStack_240;
  undefined4 uStack_23c;
  undefined4 local_238;
  undefined4 uStack_234;
  int iStack_230;
  undefined4 uStack_22c;
  undefined4 local_228;
  undefined4 uStack_224;
  undefined4 uStack_220;
  undefined4 uStack_21c;
  undefined4 local_218;
  undefined4 uStack_214;
  uint uStack_210;
  undefined4 uStack_20c;
  undefined4 local_208;
  undefined4 uStack_204;
  undefined4 uStack_200;
  undefined4 uStack_1fc;
  undefined4 uStack_1f8;
  undefined4 local_1f4;
  undefined4 uStack_1f0;
  undefined4 uStack_1ec;
  undefined4 uStack_1e8;
  undefined4 uStack_1e4;
  undefined4 local_1e0;
  undefined4 uStack_1dc;
  undefined4 local_1d8;
  undefined4 uStack_1d4;
  undefined4 uStack_1d0;
  undefined4 uStack_1cc;
  int local_1c8;
  undefined4 uStack_1c4;
  undefined4 local_188;
  undefined4 local_150;
  int local_118;
  undefined4 local_114;
  undefined4 local_110;
  undefined4 local_10c;
  undefined4 local_108;
  undefined4 local_104;
  undefined4 local_100;
  undefined4 local_fc;
  undefined4 local_f8;
  undefined4 local_f0;
  undefined4 local_ec;
  undefined4 local_e8;
  undefined4 local_e4;
  undefined4 local_e0;
  undefined4 local_dc;
  undefined4 local_d8;
  undefined4 local_d4;
  undefined4 local_d0;
  int local_cc;
  undefined4 local_c8;
  undefined4 local_c4;
  undefined4 local_c0;
  undefined4 uStack_bc;
  undefined4 local_b8;
  undefined4 uStack_b4;
  undefined4 uStack_b0;
  undefined4 uStack_ac;
  undefined4 uStack_a8;
  undefined4 local_a4;
  int iStack_a0;
  undefined4 uStack_9c;
  undefined4 uStack_98;
  undefined4 uStack_94;
  int iStack_90;
  undefined4 local_8c;
  undefined4 uStack_88;
  undefined4 uStack_84;
  undefined4 uStack_80;
  undefined4 local_7c;
  undefined4 uStack_78;
  undefined4 uStack_74;
  undefined4 uStack_70;
  undefined4 local_6c;
  undefined4 uStack_68;
  undefined4 uStack_64;
  undefined4 uStack_60;
  undefined4 uStack_5c;
  undefined4 local_58;
  undefined4 uStack_54;
  undefined4 uStack_50;
  undefined4 uStack_4c;
  undefined4 local_48;
  undefined4 uStack_44;
  undefined4 uStack_40;
  undefined4 uStack_3c;
  undefined4 local_38;
  undefined4 uStack_34;
  undefined4 uStack_30;
  undefined4 uStack_2c;
  undefined4 uStack_28;
  
  iVar5 = param_5[0x10];
  if (iVar5 - 0x1000000U < 0xff004000) {
                    /* WARNING: Subroutine does not return */
    FUN_00faa464("assertion failed: DEFAULT_MAX_FRAME_SIZE <= val && val <= MAX_MAX_FRAME_SIZE:authority:method:scheme:path:protocol:statush2::proto::connection/nix/store/eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee-vendor-cargo-deps/c19b7c6f923b580ac259164a89f2577984ad5ab09ee9d583b888f934adbbe8d0/h2-0.4.7/src/proto/connection.rs"
                 ,0x4c,&DAT_01882b98);
  }
  uVar6 = param_5[0xf];
  uVar7 = *param_5;
  uVar8 = param_5[1];
  iVar9 = param_5[2];
  uVar10 = param_5[3];
  uVar11 = param_5[4];
  uVar12 = param_5[5];
  uVar16 = param_5[0xe];
  bVar1 = *(byte *)((int)param_5 + 0x4d);
  uVar17 = param_5[0x11];
  uVar13 = param_5[0x12];
  uVar18 = *param_2;
  uVar20 = param_2[1];
  iVar22 = param_2[2];
  uVar24 = param_2[3];
  uVar19 = param_2[4];
  uVar21 = param_2[5];
  uVar23 = param_2[6];
  uVar25 = param_2[7];
  local_6e8 = 2;
  local_6d8 = DAT_018da440;
  if (DAT_018dd947 == '\0') {
    local_488 = DAT_018da440 + 0x1c;
    local_48c = 0;
    local_490 = 4;
    FUN_01694880(&local_6f0,&local_490);
  }
  local_948 = local_6f0;
  uStack_944 = local_6ec;
  local_940 = local_6e8;
  local_93c = local_6e4;
  local_938 = local_6e0;
  uStack_934 = local_6dc;
  iStack_930 = local_6d8;
  uStack_92c = local_6d4;
  if (local_6e8 != 2) {
    if ((local_6e8 & 1) != 0) {
      local_6e4 = local_6e4 + (*(int *)(local_6e0 + 8) - 1U & 0xfffffff8) + 8;
    }
    (**(code **)(local_6e0 + 0x30))(local_6e4,&local_948);
  }
  local_6d4 = 4;
  local_6e0 = 4;
  local_6bc = 0x1000;
  local_6f0 = 2;
  local_6d0 = 0;
  local_6d8 = 0;
  local_6dc = 0;
  local_6e4 = 0;
  local_6cc = 0;
  local_6c8 = 0;
  local_6c4 = 0;
  local_6c0 = 0;
  local_490 = uVar18;
  local_48c = uVar20;
  local_488 = iVar22;
  uStack_484 = uVar24;
  local_480 = uVar19;
  uStack_47c = uVar21;
  uStack_478 = uVar23;
  uStack_474 = uVar25;
  iVar14 = thunk_FUN_016d4a50(0x4000);
  if (iVar14 == 0) {
                    /* WARNING: Subroutine does not return */
    FUN_00600af4(1,0x4000);
  }
  local_218 = local_6f0;
  uStack_214 = local_6ec;
  uStack_210 = local_6e8;
  uStack_20c = local_6e4;
  local_208 = local_6e0;
  uStack_204 = local_6dc;
  uStack_200 = local_6d8;
  uStack_1fc = local_6d4;
  uStack_1f8 = local_6d0;
  local_1f4 = local_6cc;
  uStack_1f0 = local_6c8;
  uStack_1ec = local_6c4;
  uStack_1e8 = local_6c0;
  uStack_1e4 = local_6bc;
  local_238 = uVar18;
  uStack_234 = uVar20;
  iStack_230 = iVar22;
  uStack_22c = uVar24;
  local_228 = uVar19;
  uStack_224 = uVar21;
  uStack_220 = uVar23;
  uStack_21c = uVar25;
  FUN_016dd1aa(&local_6f0,&local_238,0x58);
  local_628[8] = 0x109;
  local_628[7] = 0x100;
  local_628[6] = 0x4000;
  local_628[2] = 0x4000;
  local_660 = 4;
  local_628[5] = 0;
  local_628[4] = 0;
  local_628[3] = 0x15;
  local_628[1] = 0;
  local_698 = 3;
  local_628[0] = iVar14;
  iVar22 = thunk_FUN_016d4a50(0x2000);
  if (iVar22 == 0) {
                    /* WARNING: Subroutine does not return */
    FUN_00600af4(1,0x2000);
  }
  FUN_016dd1aa(&local_1e0,&local_238,0x58);
  local_10c = 0x15;
  local_150 = 4;
  local_f8 = 0x109;
  local_fc = 0x100;
  local_c0 = 0x11;
  local_c4 = 0x2000;
  local_dc = 9;
  local_e8 = 0x800000;
  local_f0 = 1;
  local_d8 = 1;
  local_110 = 0x4000;
  local_100 = 0x4000;
  local_108 = 0;
  local_104 = 0;
  local_ec = 0;
  local_114 = 0;
  local_188 = 3;
  uStack_bc = (uint)uStack_bc._3_1_ << 0x18;
  local_c8 = 0;
  local_d4 = 0;
  local_e0 = 0;
  local_e4 = 3;
  local_118 = iVar14;
  local_cc = iVar22;
  FUN_016dd1aa(&local_490,&local_1e0,0x128);
  FUN_01011d10(&local_58);
  FUN_016dd1aa(local_628,&local_1e0,0xf8);
  local_b8 = local_e4;
  uStack_b4 = local_e0;
  uStack_b0 = local_dc;
  uStack_ac = local_d8;
  uStack_a8 = local_d4;
  local_a4 = local_d0;
  iStack_a0 = local_cc;
  uStack_9c = local_c8;
  uStack_98 = local_c4;
  uStack_94 = local_c0;
  iStack_90 = uStack_bc;
  local_8c = local_58;
  uStack_88 = uStack_54;
  uStack_84 = uStack_50;
  uStack_80 = uStack_4c;
  local_7c = local_48;
  uStack_78 = uStack_44;
  uStack_74 = uStack_40;
  uStack_70 = uStack_3c;
  local_6c = local_38;
  uStack_68 = uStack_34;
  uStack_64 = uStack_30;
  uStack_60 = uStack_2c;
  uStack_5c = uStack_28;
  local_928 = 2;
  local_924 = 0;
  FUN_016dd1aa(auStack_920,&local_6f0,0x1c0);
  local_760 = 0x4000;
  FUN_016dd1aa(auStack_75c,&local_b8,0x60);
  local_6f8 = 0x500;
  local_760 = iVar5;
  local_6fc = uVar13;
  uVar15 = FUN_018462e8(uVar13,iVar5);
  if (uVar15 < 2) {
    uVar15 = 1;
  }
  local_6b4 = 0;
  local_6f8 = uVar15 + (uVar15 >> 2);
  local_6b8 = 1;
  if (local_6f8 < uVar15) {
    local_6f8 = 0xffffffff;
  }
  if (local_6f8 < 6) {
    local_6f8 = 5;
  }
  local_6c4 = 1;
  local_6cc = 1;
  local_6d4 = 1;
  local_6e4 = 0;
  local_6ec = 0;
  local_6f0._0_1_ = 4;
  local_6dc = uVar7;
  local_6d8 = uVar8;
  local_6d0 = uVar6;
  local_6c8 = iVar5;
  local_6c0 = uVar13;
  local_6bc = (uint)bVar1;
  cVar4 = FUN_0075459c(auStack_838,&local_6f0);
  if (cVar4 != '\f') {
    local_6f0 = CONCAT31(local_6f0._1_3_,cVar4);
                    /* WARNING: Subroutine does not return */
    FUN_00fb74f8(&DAT_004089e2,0x16,&local_6f0,&DAT_01858770,&DAT_01858750);
  }
  FUN_016dd1aa(&local_6f0,&local_928,0x238);
  local_1d8 = 2;
  local_1c8 = DAT_018da434;
  if (DAT_018dd947 == '\0') {
    local_488 = DAT_018da434 + 0x1c;
    local_48c = 0;
    local_490 = 4;
    FUN_01694880(&local_1e0,&local_490);
  }
  local_258 = local_1e0;
  uStack_254 = uStack_1dc;
  uStack_250 = local_1d8;
  uStack_24c = uStack_1d4;
  uStack_248 = uStack_1d0;
  uStack_244 = uStack_1cc;
  iStack_240 = local_1c8;
  uStack_23c = uStack_1c4;
  FUN_016dd1aa(&local_490,&local_6f0,0x238);
  FUN_016dd1aa(&local_6e8,&local_490,600);
  local_6ec = 0;
  local_6f0 = 4;
  if (local_940 != 2) {
    iVar22 = local_93c;
    if ((local_940 & 1) != 0) {
      iVar22 = local_93c + (*(int *)(local_938 + 8) - 1U & 0xfffffff8) + 8;
    }
    (**(code **)(local_938 + 0x34))(iVar22,&local_948);
  }
  FUN_016dd1aa(param_1 + 2,&local_6f0,0x260);
  param_1[0xb4] = local_948;
  param_1[0xb5] = uStack_944;
  param_1[0xb6] = local_940;
  param_1[0xb7] = local_93c;
  param_1[0xb8] = local_938;
  param_1[0xb9] = uStack_934;
  param_1[0xba] = iStack_930;
  param_1[0xbb] = uStack_92c;
  param_1[0xf2] = param_3;
  *param_1 = 3;
  param_1[0xf3] = param_4;
  param_1[0xf4] = param_6;
  param_1[0xf5] = param_7;
  param_1[0x9d] = uVar12;
  param_1[0x9c] = uVar11;
  param_1[0x9b] = uVar16;
  if (iVar9 == 0) {
    uVar10 = 0x14;
  }
  param_1[0x9e] = 0x1e;
  param_1[0xb2] = uVar10;
  param_1[0xb1] = 10;
  param_1[0xb3] = uVar17;
  bVar2 = *(byte *)(param_5 + 0x13);
  param_1[0xbd] = uVar6;
  param_1[0xa9] = uVar6;
  uVar11 = param_5[6];
  uVar12 = param_5[7];
  uVar6 = param_5[10];
  uVar16 = param_5[8];
  uVar10 = param_5[0xc];
  param_1[0xae] = (uint)bVar1;
  uVar3 = *(undefined1 *)((int)param_5 + 0x4e);
  param_1[0xbc] = (uint)bVar2;
  param_1[0xa6] = uVar7;
  param_1[0xab] = iVar5;
  uVar7 = param_5[0xb];
  param_1[0xc2] = uVar6;
  param_1[1] = 0;
  param_1[0x9f] = 0;
  param_1[0x9a] = 1;
  *(undefined1 *)(param_1 + 0xb0) = 0;
  param_1[0xaf] = 1;
  param_1[0xa7] = uVar8;
  param_1[0xa8] = 1;
  param_1[0xaa] = 1;
  param_1[0xac] = 1;
  param_1[0xad] = uVar13;
  param_1[0xa4] = 0;
  param_1[0xa2] = 0;
  param_1[0xa0] = 0;
  param_1[0xbe] = uVar11;
  param_1[0xbf] = uVar12;
  param_1[0xc0] = uVar16;
  param_1[0xc3] = uVar7;
  param_1[0xc4] = uVar10;
  *(undefined1 *)((int)param_1 + 0x3d9) = 0;
  *(undefined1 *)(param_1 + 0xf6) = uVar3;
  *(undefined1 *)(param_1 + 0xc6) = 1;
  return;
}

