// FUN_01825fac @ 01825fac size=1432 calls_out=4 calls_in=4
// strings: 

void FUN_01825fac(undefined4 param_1,int *param_2)

{
  int iVar1;
  undefined1 auStack_234 [40];
  int local_20c;
  int iStack_208;
  int iStack_204;
  int iStack_200;
  int local_1fc;
  int iStack_1f8;
  int iStack_1f4;
  int iStack_1f0;
  int local_1ec;
  int iStack_1e8;
  int local_1e4;
  int iStack_1e0;
  int iStack_1dc;
  int iStack_1d8;
  int local_1d4;
  int iStack_1d0;
  int iStack_1cc;
  int iStack_1c8;
  int local_1c4;
  int iStack_1c0;
  int local_1bc;
  int iStack_1b8;
  int iStack_1b4;
  int iStack_1b0;
  int local_1ac;
  int iStack_1a8;
  int iStack_1a4;
  int iStack_1a0;
  int local_19c;
  int iStack_198;
  int local_194;
  int iStack_190;
  int iStack_18c;
  int iStack_188;
  int local_184;
  int iStack_180;
  int iStack_17c;
  int iStack_178;
  int local_174;
  int iStack_170;
  int local_16c;
  int iStack_168;
  int iStack_164;
  int iStack_160;
  int local_15c;
  int iStack_158;
  int iStack_154;
  int iStack_150;
  int local_14c;
  int iStack_148;
  int local_144;
  int iStack_140;
  int iStack_13c;
  int iStack_138;
  int local_134;
  int iStack_130;
  int iStack_12c;
  int iStack_128;
  int local_124;
  int iStack_120;
  int local_11c;
  int iStack_118;
  int iStack_114;
  int iStack_110;
  int local_10c;
  int iStack_108;
  int iStack_104;
  int iStack_100;
  int local_fc;
  int iStack_f8;
  int local_f4;
  int iStack_f0;
  int iStack_ec;
  int iStack_e8;
  int local_e4;
  int iStack_e0;
  int iStack_dc;
  int iStack_d8;
  int local_d4;
  int iStack_d0;
  int local_cc;
  int iStack_c8;
  int iStack_c4;
  int iStack_c0;
  int local_bc;
  int iStack_b8;
  int iStack_b4;
  int iStack_b0;
  int local_ac;
  int iStack_a8;
  int local_a4;
  int local_a0;
  int local_9c;
  int local_98;
  int local_94;
  int local_90;
  int local_8c;
  int local_88;
  int local_84;
  int iStack_80;
  int local_7c;
  int local_78;
  int local_74;
  int local_70;
  int local_6c;
  int local_68;
  int local_64;
  int local_60;
  int local_5c;
  int local_58;
  int local_54;
  int local_50;
  int local_4c;
  int local_48;
  int local_44;
  int local_40;
  int local_3c;
  int local_38;
  int local_34;
  int local_30;
  int local_2c;
  
  local_2c = DAT_018ddaf8;
  FUN_0181f914(auStack_234,param_2,&PTR_018bc3f4,0);
  FUN_0181f130(auStack_234,auStack_234,param_2);
  FUN_0181f914(&local_20c,auStack_234);
  FUN_0181f130(&local_20c,&local_20c,param_2);
  iVar1 = 3;
  local_1e4 = local_20c;
  iStack_1e0 = iStack_208;
  iStack_1dc = iStack_204;
  iStack_1d8 = iStack_200;
  local_1d4 = local_1fc;
  iStack_1d0 = iStack_1f8;
  iStack_1cc = iStack_1f4;
  iStack_1c8 = iStack_1f0;
  local_1c4 = local_1ec;
  iStack_1c0 = iStack_1e8;
  do {
    FUN_0181f914(&local_1e4,&local_1e4);
    iVar1 = iVar1 + -1;
  } while (iVar1 != 0);
  iVar1 = 3;
  FUN_0181f130(&local_1e4,&local_1e4,&local_20c);
  local_1bc = local_1e4;
  iStack_1b8 = iStack_1e0;
  iStack_1b4 = iStack_1dc;
  iStack_1b0 = iStack_1d8;
  local_1ac = local_1d4;
  iStack_1a8 = iStack_1d0;
  iStack_1a4 = iStack_1cc;
  iStack_1a0 = iStack_1c8;
  local_19c = local_1c4;
  iStack_198 = iStack_1c0;
  do {
    FUN_0181f914(&local_1bc,&local_1bc);
    iVar1 = iVar1 + -1;
  } while (iVar1 != 0);
  FUN_0181f130(&local_1bc,&local_1bc,&local_20c);
  iVar1 = 0xb;
  local_194 = local_1bc;
  iStack_190 = iStack_1b8;
  iStack_18c = iStack_1b4;
  iStack_188 = iStack_1b0;
  local_184 = local_1ac;
  iStack_180 = iStack_1a8;
  iStack_17c = iStack_1a4;
  iStack_178 = iStack_1a0;
  local_174 = local_19c;
  iStack_170 = iStack_198;
  FUN_0181f914(&local_194,&local_194);
  FUN_0181f914(&local_194,&local_194);
  FUN_0181f130(&local_194,&local_194,auStack_234);
  local_16c = local_194;
  iStack_168 = iStack_190;
  iStack_164 = iStack_18c;
  iStack_160 = iStack_188;
  local_15c = local_184;
  iStack_158 = iStack_180;
  iStack_154 = iStack_17c;
  iStack_150 = iStack_178;
  local_14c = local_174;
  iStack_148 = iStack_170;
  do {
    FUN_0181f914(&local_16c,&local_16c);
    iVar1 = iVar1 + -1;
  } while (iVar1 != 0);
  FUN_0181f130(&local_16c,&local_16c,&local_194);
  iVar1 = 0x16;
  local_144 = local_16c;
  iStack_140 = iStack_168;
  iStack_13c = iStack_164;
  iStack_138 = iStack_160;
  local_134 = local_15c;
  iStack_130 = iStack_158;
  iStack_12c = iStack_154;
  iStack_128 = iStack_150;
  local_124 = local_14c;
  iStack_120 = iStack_148;
  do {
    FUN_0181f914(&local_144,&local_144);
    iVar1 = iVar1 + -1;
  } while (iVar1 != 0);
  FUN_0181f130(&local_144,&local_144,&local_16c);
  iVar1 = 0x2c;
  local_11c = local_144;
  iStack_118 = iStack_140;
  iStack_114 = iStack_13c;
  iStack_110 = iStack_138;
  local_10c = local_134;
  iStack_108 = iStack_130;
  iStack_104 = iStack_12c;
  iStack_100 = iStack_128;
  local_fc = local_124;
  iStack_f8 = iStack_120;
  do {
    FUN_0181f914(&local_11c,&local_11c);
    iVar1 = iVar1 + -1;
  } while (iVar1 != 0);
  FUN_0181f130(&local_11c,&local_11c,&local_144);
  iVar1 = 0x58;
  local_f4 = local_11c;
  iStack_f0 = iStack_118;
  iStack_ec = iStack_114;
  iStack_e8 = iStack_110;
  local_e4 = local_10c;
  iStack_e0 = iStack_108;
  iStack_dc = iStack_104;
  iStack_d8 = iStack_100;
  local_d4 = local_fc;
  iStack_d0 = iStack_f8;
  do {
    FUN_0181f914(&local_f4,&local_f4);
    iVar1 = iVar1 + -1;
  } while (iVar1 != 0);
  FUN_0181f130(&local_f4,&local_f4,&local_11c);
  iVar1 = 0x2c;
  local_cc = local_f4;
  iStack_c8 = iStack_f0;
  iStack_c4 = iStack_ec;
  iStack_c0 = iStack_e8;
  local_bc = local_e4;
  iStack_b8 = iStack_e0;
  iStack_b4 = iStack_dc;
  iStack_b0 = iStack_d8;
  local_ac = local_d4;
  iStack_a8 = iStack_d0;
  do {
    FUN_0181f914(&local_cc,&local_cc);
    iVar1 = iVar1 + -1;
  } while (iVar1 != 0);
  iVar1 = 3;
  FUN_0181f130(&local_cc,&local_cc,&local_144);
  local_a4 = local_cc;
  local_a0 = iStack_c8;
  local_9c = iStack_c4;
  local_98 = iStack_c0;
  local_94 = local_bc;
  local_90 = iStack_b8;
  local_8c = iStack_b4;
  local_88 = iStack_b0;
  local_84 = local_ac;
  iStack_80 = iStack_a8;
  do {
    FUN_0181f914(&local_a4,&local_a4);
    iVar1 = iVar1 + -1;
  } while (iVar1 != 0);
  iVar1 = 0x17;
  FUN_0181f130(&local_a4,&local_a4,&local_20c);
  local_68 = local_90;
  local_70 = local_98;
  local_5c = local_84;
  local_58 = iStack_80;
  local_6c = local_94;
  local_74 = local_9c;
  local_78 = local_a0;
  local_7c = local_a4;
  local_60 = local_88;
  local_64 = local_8c;
  do {
    FUN_0181f914(&local_7c,&local_7c);
    iVar1 = iVar1 + -1;
  } while (iVar1 != 0);
  iVar1 = 6;
  FUN_0181f130(&local_7c,&local_7c,&local_16c);
  do {
    FUN_0181f914(&local_7c,&local_7c);
    iVar1 = iVar1 + -1;
  } while (iVar1 != 0);
  FUN_0181f130(&local_7c,&local_7c,auStack_234);
  FUN_0181f914(&local_7c,&local_7c);
  FUN_0181f914(param_1,&local_7c);
  FUN_0181f914(&local_7c,param_1);
  local_50 = param_2[1] + (0xffffefc - local_78);
  local_30 = param_2[9] + (0xfffffc - local_58);
  local_54 = (0xffff0bc - local_7c) + *param_2;
  local_4c = param_2[2] + (0xffffffc - local_74);
  local_48 = param_2[3] + (0xffffffc - local_70);
  local_44 = param_2[4] + (0xffffffc - local_6c);
  local_40 = param_2[5] + (0xffffffc - local_68);
  local_3c = param_2[6] + (0xffffffc - local_64);
  local_38 = param_2[7] + (0xffffffc - local_60);
  local_34 = param_2[8] + (0xffffffc - local_5c);
  FUN_0181eba4(&local_54);
  if (local_2c != DAT_018ddaf8) {
                    /* WARNING: Subroutine does not return */
    FUN_016d2b78();
  }
  return;
}

