// FUN_007af038 @ 007af038 size=6552 calls_out=31 calls_in=0
// strings: early eof | decryption failed | decryption failed | not implemented | BUG: remote static pubkey is missing even though handshake is finished | BUG: Hash should be 32 bytes arrayBroken certificateSystem time is invalidCertificate is not yet validCertificate is no more validSignature is invalidPublic key is invalidii_stratum_proxy::translationopen/protocols/stratum-proxy/src/translation.rs

/* WARNING: Restarted to delay deadcode elimination for space: stack */

void FUN_007af038(uint *param_1,uint *param_2,undefined4 param_3)

{
  byte bVar1;
  undefined1 uVar2;
  undefined2 uVar3;
  uint uVar4;
  char *pcVar5;
  uint uVar6;
  uint uVar7;
  uint *puVar8;
  uint *puVar9;
  undefined2 *puVar10;
  uint uVar11;
  int *piVar12;
  undefined4 *puVar13;
  undefined1 *puVar14;
  uint uVar15;
  undefined4 uVar16;
  uint uVar17;
  undefined *puVar18;
  undefined4 *puVar19;
  char *pcVar20;
  undefined2 *puVar21;
  int iVar22;
  uint uVar23;
  uint uVar24;
  bool bVar25;
  undefined4 local_2270;
  undefined2 *local_2268;
  undefined4 *local_2264;
  uint *local_2244;
  undefined2 local_2240;
  undefined4 local_223e;
  undefined4 local_223a;
  undefined1 auStack_2236 [64];
  undefined4 local_21f6;
  undefined4 local_21f2;
  undefined4 local_21ee;
  undefined4 local_21ea;
  undefined2 local_21e0;
  undefined1 uStack_21de;
  uint uStack_21dd;
  undefined4 *puStack_21d9;
  byte local_21d5;
  undefined4 local_21d0;
  undefined4 uStack_21cc;
  undefined4 uStack_21c8;
  undefined3 uStack_21c4;
  undefined4 local_21c0;
  undefined4 uStack_21bc;
  undefined4 uStack_21b8;
  undefined4 uStack_21b4;
  undefined4 uStack_21b0;
  undefined4 local_21ac;
  undefined4 uStack_21a8;
  undefined4 uStack_21a4;
  undefined4 uStack_21a0;
  undefined4 uStack_219c;
  undefined4 local_2198;
  undefined4 uStack_2194;
  undefined4 uStack_2190;
  undefined4 uStack_218c;
  undefined4 uStack_2188;
  undefined4 uStack_2184;
  undefined1 auStack_2180 [1100];
  uint local_1d34;
  uint uStack_1d30;
  uint uStack_1d2c;
  uint uStack_1d28;
  uint local_1d24;
  uint uStack_1d20;
  uint uStack_1d1c;
  uint uStack_1d18;
  uint local_1d10;
  char *pcStack_1d0c;
  uint uStack_1d08;
  uint uStack_1d04;
  int local_1d00;
  undefined4 uStack_1cfc;
  int iStack_1cf8;
  undefined4 uStack_1cf4;
  uint local_1cf0;
  char *pcStack_1cec;
  uint uStack_1ce8;
  uint uStack_1ce4;
  int iStack_1ce0;
  undefined4 local_1cdc;
  int iStack_1cd8;
  undefined4 uStack_1cd4;
  uint uStack_1cd0;
  uint uStack_1ccc;
  uint local_1cc8;
  uint uStack_1cc4;
  uint uStack_1cc0;
  uint uStack_1cbc;
  uint uStack_1cb8;
  uint uStack_1cb4;
  uint local_1cb0;
  char *pcStack_1cac;
  uint uStack_1ca8;
  uint uStack_1ca4;
  int local_1ca0;
  undefined4 uStack_1c9c;
  int iStack_1c98;
  undefined4 uStack_1c94;
  uint local_1c90;
  char *pcStack_1c8c;
  uint uStack_1c88;
  uint uStack_1c84;
  int local_1c80;
  undefined4 uStack_1c7c;
  int iStack_1c78;
  undefined4 uStack_1c74;
  uint local_1c70;
  uint uStack_1c6c;
  uint uStack_1c68;
  uint uStack_1c64;
  uint local_1c60;
  uint uStack_1c5c;
  uint uStack_1c58;
  uint uStack_1c54;
  uint local_1c50;
  uint local_1c4c;
  uint local_1c48;
  uint local_1c44;
  undefined4 local_1c40;
  undefined4 uStack_1c3c;
  undefined4 uStack_1c38;
  undefined3 uStack_1c34;
  undefined4 local_1c30;
  undefined4 uStack_1c2c;
  undefined4 uStack_1c28;
  undefined4 uStack_1c24;
  undefined4 uStack_1c20;
  undefined4 local_1c1c;
  undefined4 uStack_1c18;
  undefined4 uStack_1c14;
  undefined4 uStack_1c10;
  undefined4 uStack_1c0c;
  undefined4 local_1c08;
  undefined4 uStack_1c04;
  undefined4 uStack_1c00;
  undefined4 uStack_1bfc;
  undefined4 uStack_1bf8;
  undefined4 uStack_1bf4;
  undefined1 auStack_1bf0 [1136];
  byte local_1780;
  byte bStack_177f;
  undefined1 uStack_177e;
  undefined1 uStack_177d;
  undefined1 local_177c;
  undefined2 uStack_177b;
  uint uStack_1779;
  uint uStack_1775;
  undefined1 uStack_1771;
  undefined4 local_1770;
  undefined4 local_176c;
  int local_1768;
  undefined4 local_1764;
  undefined1 auStack_174f [79];
  undefined4 local_1700;
  undefined4 uStack_16fc;
  undefined4 uStack_16f8;
  undefined4 uStack_16f4;
  undefined4 uStack_16f0;
  undefined4 local_16ec;
  undefined4 uStack_16e8;
  undefined4 uStack_16e4;
  undefined4 uStack_16e0;
  undefined4 uStack_16dc;
  undefined4 local_16d8;
  undefined4 uStack_16d4;
  undefined4 uStack_16d0;
  undefined4 uStack_16cc;
  undefined4 uStack_16c8;
  undefined4 uStack_16c4;
  undefined4 local_16c0;
  undefined4 local_16bc;
  undefined4 *local_16b8;
  undefined4 local_16b0;
  undefined1 auStack_13d0 [276];
  undefined2 local_12bc;
  undefined1 local_12ba;
  uint local_12b8;
  undefined4 uStack_12b4;
  undefined4 uStack_12b0;
  uint uStack_12ac;
  uint local_12a8;
  uint uStack_12a4;
  uint uStack_12a0;
  uint uStack_129c;
  uint local_11d8;
  uint uStack_11d4;
  uint uStack_11d0;
  uint uStack_11cc;
  uint local_11c8;
  uint uStack_11c4;
  uint uStack_11c0;
  uint uStack_11bc;
  undefined4 local_11b8;
  undefined4 uStack_11b4;
  undefined4 uStack_11b0;
  undefined4 uStack_11ac;
  undefined4 local_11a8;
  undefined4 uStack_11a4;
  undefined4 uStack_11a0;
  undefined4 uStack_119c;
  undefined1 auStack_1198 [160];
  uint local_10f8;
  undefined4 uStack_10f4;
  int iStack_10f0;
  int iStack_10ec;
  int iStack_10e8;
  undefined4 uStack_10e4;
  int iStack_10e0;
  undefined4 uStack_10dc;
  undefined2 local_10d4;
  undefined1 local_10d2;
  byte local_10d0;
  byte bStack_10cf;
  undefined1 uStack_10ce;
  undefined1 uStack_10cd;
  undefined2 local_10cc;
  undefined1 uStack_10ca;
  uint uStack_10c9;
  uint uStack_10c5;
  undefined1 uStack_10c1;
  undefined4 local_10c0;
  undefined4 local_10bc;
  int local_10b8;
  undefined4 uStack_10b4;
  undefined4 local_10b0;
  undefined4 uStack_10ac;
  undefined4 local_10a8;
  undefined4 uStack_10a4;
  undefined4 local_10a0;
  undefined4 uStack_109c;
  undefined4 uStack_1098;
  undefined4 uStack_1094;
  int local_1008;
  undefined4 local_1000;
  undefined1 auStack_fac [268];
  uint local_ea0;
  char *local_e9c;
  uint local_e98;
  undefined1 auStack_e94 [548];
  undefined4 local_c70;
  undefined4 uStack_c6c;
  undefined4 uStack_c68;
  undefined4 uStack_c64;
  undefined4 local_c60;
  undefined4 uStack_c5c;
  undefined4 uStack_c58;
  undefined4 uStack_c54;
  undefined1 local_c50;
  undefined1 auStack_c4f [79];
  uint local_c00;
  uint uStack_bfc;
  uint uStack_bf8;
  uint uStack_bf4;
  uint local_bf0;
  uint uStack_bec;
  uint uStack_be8;
  uint uStack_be4;
  undefined4 local_be0;
  undefined4 uStack_bdc;
  undefined4 uStack_bd8;
  undefined4 uStack_bd4;
  undefined4 local_bd0;
  undefined4 uStack_bcc;
  undefined4 uStack_bc8;
  undefined4 uStack_bc4;
  undefined4 local_bc0;
  undefined4 uStack_bbc;
  undefined4 uStack_bb8;
  undefined4 uStack_bb4;
  int iStack_bb0;
  undefined4 uStack_bac;
  int iStack_ba8;
  undefined4 uStack_ba4;
  uint local_b80;
  char *pcStack_b7c;
  uint uStack_b78;
  uint uStack_b74;
  int iStack_b70;
  undefined4 local_b6c;
  int iStack_b68;
  undefined4 uStack_b64;
  uint uStack_b60;
  uint uStack_b5c;
  uint local_b58;
  uint uStack_b54;
  uint uStack_b50;
  uint uStack_b4c;
  uint uStack_b48;
  uint uStack_b44;
  undefined4 local_b40;
  undefined4 uStack_b3c;
  undefined4 uStack_b38;
  undefined4 uStack_b34;
  undefined4 local_b30;
  undefined4 uStack_b2c;
  undefined4 uStack_b28;
  undefined4 uStack_b24;
  uint local_b20;
  uint uStack_b1c;
  uint uStack_b18;
  uint uStack_b14;
  uint uStack_b10;
  uint local_b0c;
  uint uStack_b08;
  uint uStack_b04;
  uint uStack_b00;
  uint uStack_afc;
  uint local_af8;
  uint uStack_af4;
  uint uStack_af0;
  uint uStack_aec;
  uint uStack_ae8;
  uint uStack_ae4;
  undefined1 auStack_ae0 [32];
  uint local_ac0;
  uint uStack_abc;
  uint uStack_ab8;
  uint uStack_ab4;
  uint local_ab0;
  uint uStack_aac;
  uint uStack_aa8;
  uint uStack_aa4;
  uint local_aa0;
  char *pcStack_a9c;
  uint uStack_a98;
  uint uStack_a94;
  int local_a90;
  undefined4 uStack_a8c;
  int iStack_a88;
  undefined4 uStack_a84;
  undefined2 local_a80;
  undefined2 uStack_a7e;
  undefined2 local_a7c;
  undefined2 uStack_a7a;
  undefined2 local_a78;
  undefined2 uStack_a76;
  uint local_a74;
  uint local_a70;
  uint local_a6c;
  uint local_a68;
  uint local_a64;
  uint local_a60;
  uint uStack_a5c;
  uint local_a58;
  uint uStack_a54;
  uint local_a50;
  uint uStack_a4c;
  uint uStack_a48;
  uint uStack_a44;
  undefined *local_870;
  undefined4 local_860;
  undefined4 local_85c;
  uint local_850;
  undefined4 uStack_84c;
  undefined4 uStack_848;
  undefined4 uStack_844;
  undefined4 uStack_840;
  undefined4 local_83c;
  undefined4 uStack_838;
  undefined4 uStack_834;
  undefined4 uStack_830;
  uint uStack_82c;
  uint local_828;
  uint uStack_824;
  uint uStack_820;
  uint uStack_81c;
  uint uStack_818;
  uint uStack_814;
  undefined1 auStack_800 [32];
  uint local_7e0;
  undefined4 uStack_7dc;
  undefined4 uStack_7d8;
  undefined4 uStack_7d4;
  undefined4 uStack_7d0;
  undefined4 local_7cc;
  undefined4 uStack_7c8;
  undefined4 uStack_7c4;
  undefined4 uStack_7c0;
  uint uStack_7bc;
  uint local_7b8;
  uint uStack_7b4;
  uint uStack_7b0;
  uint uStack_7ac;
  uint uStack_7a8;
  uint uStack_7a4;
  uint local_7a0;
  undefined4 uStack_79c;
  undefined4 uStack_798;
  undefined4 uStack_794;
  undefined4 local_790;
  undefined4 uStack_78c;
  undefined4 uStack_788;
  undefined4 uStack_784;
  uint local_780;
  uint local_77c;
  uint local_778;
  uint local_774;
  uint local_770;
  uint local_76c;
  uint local_768;
  uint local_764;
  uint local_760;
  uint uStack_75c;
  uint local_758;
  uint uStack_754;
  uint uStack_750;
  uint uStack_74c;
  uint uStack_748;
  uint uStack_744;
  undefined *local_570;
  undefined4 local_560;
  undefined4 local_55c;
  undefined4 local_548;
  undefined4 uStack_544;
  undefined4 uStack_540;
  undefined4 uStack_53c;
  undefined4 local_538;
  undefined4 uStack_534;
  undefined4 uStack_530;
  undefined4 uStack_52c;
  uint local_528;
  char *pcStack_524;
  uint uStack_520;
  uint uStack_51c;
  int local_518;
  undefined4 uStack_514;
  int iStack_510;
  undefined4 uStack_50c;
  uint local_508;
  uint uStack_504;
  uint uStack_500;
  uint uStack_4fc;
  uint local_4f8;
  uint uStack_4f4;
  uint uStack_4f0;
  uint uStack_4ec;
  uint local_4e8;
  uint uStack_4e4;
  uint uStack_4e0;
  undefined4 local_4dc;
  uint local_4d8;
  uint uStack_4d4;
  uint uStack_4d0;
  uint uStack_4cc;
  uint local_2c0;
  char *local_2bc;
  uint local_2b8;
  uint local_2b4;
  int local_2b0;
  undefined4 local_2ac;
  int iStack_2a8;
  undefined4 uStack_2a4;
  uint local_2a0;
  uint local_29c;
  uint local_298;
  uint uStack_294;
  uint local_290;
  uint local_28c;
  uint local_288;
  uint local_284;
  uint local_280;
  uint uStack_27c;
  uint uStack_278;
  uint uStack_274;
  uint uStack_270;
  uint local_26c;
  uint uStack_268;
  uint uStack_264;
  uint uStack_260;
  uint uStack_25c;
  uint local_258;
  uint uStack_254;
  uint uStack_250;
  uint uStack_24c;
  uint uStack_248;
  uint uStack_244;
  undefined4 local_90;
  undefined4 local_8c;
  undefined4 local_88;
  undefined4 local_84;
  uint local_70;
  char *local_6c;
  uint local_68;
  uint local_64;
  int local_60;
  undefined4 local_5c;
  int local_58;
  undefined4 local_54;
  undefined4 local_4c;
  undefined4 local_48;
  undefined4 local_44;
  undefined4 local_40;
  undefined4 local_3c;
  undefined4 local_38;
  undefined4 local_34;
  
  puVar8 = (uint *)((uint)&local_10d0 | 0xb);
  local_2244 = param_2 + 1;
                    /* WARNING (jumptable): Sanity check requires truncation of jumptable */
                    /* WARNING: Could not find normalized switch variable to match jumptable */
  switch(*(undefined1 *)((int)param_2 + 0x5c6)) {
  case 0:
    local_10d0 = 0x92;
    bStack_10cf = 0x2f;
    uStack_10ce = 0xa3;
    uStack_10cd = 0x2e;
    local_10cc = 0x484f;
    uStack_10ca = 0x7c;
    uStack_10c9 = 0xa3ca590d;
    uStack_10c5._0_1_ = 0xbe;
    uStack_10c5._1_3_ = 0x9c89d7;
    uStack_10c1 = 0xe3;
    local_10c0 = -0x1e487227;
    local_10bc = 0x7c3bbd3d;
    local_10b8 = 0xd43dd2f2;
    uStack_10b4 = 0x461dc33;
    local_10b0 = 0x8178b42e;
    uStack_10ac = 0xee9e8e20;
    local_10a8 = 0x679f661f;
    uStack_10a4 = 0xee76ec6;
    local_10a0 = 0x988eaa9;
    uStack_109c = 0xe83f500d;
    uStack_1098 = 0xc84bdc30;
    uStack_1094 = 0x10bf293e;
    *local_2244 = 0x2ea32f92;
    param_2[2] = 0xd7c484f;
    param_2[3] = 0xbea3ca59;
    param_2[4] = 0xe39c89d7;
    param_2[5] = 0xe1b78dd9;
    param_2[6] = 0x7c3bbd3d;
    param_2[7] = 0xd43dd2f2;
    param_2[8] = 0x461dc33;
    param_2[9] = 0x8178b42e;
    param_2[10] = 0xee9e8e20;
    param_2[0xb] = 0x679f661f;
    param_2[0xc] = 0xee76ec6;
    param_2[0xd] = 0x988eaa9;
    param_2[0xe] = 0xe83f500d;
    param_2[0xf] = 0xc84bdc30;
    param_2[0x10] = 0x10bf293e;
    puVar9 = param_2 + 0x137;
    FUN_016dd606(puVar9,0,0xea);
    *param_2 = 7;
    local_a74 = param_2[4];
    local_a70 = param_2[5];
    local_a80 = (undefined2)*local_2244;
    uStack_a7e = (undefined2)(*local_2244 >> 0x10);
    local_a7c = (undefined2)param_2[2];
    uStack_a7a = (undefined2)(param_2[2] >> 0x10);
    local_a78 = (undefined2)param_2[3];
    uStack_a76 = (undefined2)(param_2[3] >> 0x10);
    local_a6c = param_2[6];
    local_a68 = param_2[7];
    local_a64 = param_2[8];
    local_a60 = param_2[9];
    uStack_a5c = param_2[10];
    local_a58 = param_2[0xb];
    uStack_a54 = param_2[0xc];
    local_a50 = param_2[0xd];
    uStack_a4c = param_2[0xe];
    uStack_a48 = param_2[0xf];
    uStack_a44 = param_2[0x10];
    local_10b8 = DAT_018da614;
    uStack_10c9 = CONCAT31(2,(undefined1)uStack_10c9);
    uStack_10c5 = (uint)uStack_10c5._1_3_ << 8;
    if (DAT_018dd947 == '\0') {
      uStack_1775._0_1_ = (undefined1)((uint)(DAT_018da614 + 0x1c) >> 0x18);
      local_177c = 0;
      uStack_177b = 0;
      uStack_1779 = (DAT_018da614 + 0x1c) * 0x100;
      local_1780 = 4;
      bStack_177f = 0;
      uStack_177e = 0;
      uStack_177d = 0;
      FUN_01694880(&local_10d0,&local_1780);
    }
    local_1780 = local_10d0;
    bStack_177f = bStack_10cf;
    uStack_177e = uStack_10ce;
    uStack_177d = uStack_10cd;
    local_177c = (undefined1)local_10cc;
    uStack_177b = (undefined2)(CONCAT12(uStack_10ca,local_10cc) >> 8);
    uStack_1779 = uStack_10c9;
    uStack_1775 = uStack_10c5;
    uStack_1771 = uStack_10c1;
    local_1770 = local_10c0;
    local_176c = local_10bc;
    local_1768 = local_10b8;
    local_1764 = uStack_10b4;
    if (CONCAT13((undefined1)uStack_10c5,uStack_10c9._1_3_) != 2) {
      iVar22 = CONCAT13(uStack_10c1,uStack_10c5._1_3_);
      if ((uStack_10c9 & 0x100) != 0) {
        iVar22 = iVar22 + (*(int *)(local_10c0 + 8) - 1U & 0xfffffff8) + 8;
      }
      (**(code **)(local_10c0 + 0x30))(iVar22,&local_1780);
    }
    local_bc0 = CONCAT13(uStack_177d,CONCAT12(uStack_177e,CONCAT11(bStack_177f,local_1780)));
    uStack_bbc = CONCAT13((undefined1)uStack_1779,CONCAT21(uStack_177b,local_177c));
    uStack_bb8 = CONCAT13((undefined1)uStack_1775,uStack_1779._1_3_);
    uStack_bb4 = CONCAT13(uStack_1771,uStack_1775._1_3_);
    iStack_bb0 = local_1770;
    uStack_bac = local_176c;
    iStack_ba8 = local_1768;
    uStack_ba4 = local_1764;
    local_12b8 = CONCAT22(uStack_a7e,local_a80);
    uStack_12b4 = CONCAT22(uStack_a7a,local_a7c);
    uStack_12b0 = CONCAT22(uStack_a76,local_a78);
    uStack_12ac = local_a74;
    local_12a8 = local_a70;
    uStack_12a4 = local_a6c;
    uStack_12a0 = local_a68;
    uStack_129c = local_a64;
    local_11d8 = local_a60;
    uStack_11d4 = uStack_a5c;
    uStack_11d0 = local_a58;
    uStack_11cc = uStack_a54;
    local_11c8 = local_a50;
    uStack_11c4 = uStack_a4c;
    uStack_11c0 = uStack_a48;
    uStack_11bc = uStack_a44;
    FUN_006a42dc(&local_2c0);
    local_780 = local_280;
    local_77c = uStack_27c;
    local_778 = uStack_278;
    local_774 = uStack_274;
    local_770 = uStack_270;
    local_76c = local_26c;
    local_768 = uStack_268;
    local_764 = uStack_264;
    local_760 = uStack_260;
    uStack_75c = uStack_25c;
    local_758 = local_258;
    uStack_754 = uStack_254;
    uStack_750 = uStack_250;
    uStack_74c = uStack_24c;
    uStack_748 = uStack_248;
    uStack_744 = uStack_244;
    FUN_01110994(auStack_13d0,&local_12b8,&local_780,0x40);
    FUN_01110994(&local_4e8,auStack_13d0,1,0);
    uVar23 = uStack_4e0;
    uVar15 = uStack_4e4;
    uVar11 = local_4e8;
    *puVar9 = local_280;
    param_2[0x138] = uStack_27c;
    param_2[0x139] = uStack_278;
    param_2[0x13a] = uStack_274;
    param_2[0x13b] = uStack_270;
    param_2[0x13c] = local_26c;
    param_2[0x13d] = uStack_268;
    param_2[0x13e] = uStack_264;
    param_2[0x13f] = uStack_260;
    param_2[0x140] = uStack_25c;
    param_2[0x141] = local_258;
    param_2[0x142] = uStack_254;
    param_2[0x143] = uStack_250;
    param_2[0x144] = uStack_24c;
    param_2[0x145] = uStack_248;
    param_2[0x146] = uStack_244;
    local_10d0 = (byte)local_4dc;
    bStack_10cf = (byte)(local_4dc >> 8);
    uStack_10ce = local_4dc._2_1_;
    FUN_016dd1aa(&local_1780,(int)&local_4dc + 3,0x11);
    FUN_016dd1aa((int)&local_1770 + 1,&local_11d8,0x20);
    FUN_016dd1aa(auStack_174f,&local_2c0,0xa0);
    FUN_016dd1aa((uint)&local_10d0 | 3,&local_1780,0xd1);
    FUN_0110d7bc(&local_bc0);
    *param_2 = 4;
    param_2[1] = uVar11;
    param_2[2] = uVar15;
    param_2[3] = uVar23;
    FUN_016dd1aa(param_2 + 4,&local_10d0,0xd4);
    *(undefined1 *)(param_2 + 0x120) = 0;
    uVar11 = 0x40;
    param_2[0x174] = (uint)(param_2 + 0x134);
    param_2[0x175] = (uint)puVar9;
    param_2[0x176] = 0x40;
    param_2[0x136] = 0x40;
    break;
  case 1:
                    /* WARNING: Subroutine does not return */
    FUN_00fb7ca0(&DAT_0185d6ec);
  case 2:
                    /* WARNING: Subroutine does not return */
    FUN_00fb7cc0(&DAT_0185d6ec);
  case 3:
    uVar11 = param_2[0x176];
    break;
  case 4:
    uVar15 = param_2[0x176];
    uVar11 = param_2[0x177];
LAB_007af490:
    puVar19 = (undefined4 *)((uint)&local_10d0 | 1);
    do {
      iVar22 = uVar15 - uVar11;
      if (uVar15 == uVar11) {
        local_177c = (undefined1)uVar11;
        uStack_177b = (undefined2)(uVar11 >> 8);
        uStack_1779._0_1_ = (undefined1)(uVar11 >> 0x18);
        uVar11 = CONCAT13(uStack_177d,CONCAT12(uStack_177e,CONCAT11(bStack_177f,4)));
        local_1780 = 4;
        goto joined_r0x007af9bc;
      }
      FUN_01642868(&local_10d0,*(undefined4 *)param_2[0x174],param_3,param_2 + 0x175);
      if (local_10d0 != 4) {
        if (local_10d0 == 5) goto LAB_007afaf0;
        uVar16 = *puVar19;
        uStack_177b = (undefined2)((uint)*(undefined4 *)((int)puVar19 + 3) >> 8);
        uStack_1779._0_1_ = (undefined1)((uint)*(undefined4 *)((int)puVar19 + 3) >> 0x18);
        bStack_177f = (byte)uVar16;
        uStack_177e = (undefined1)((uint)uVar16 >> 8);
        uStack_177d = (undefined1)((uint)uVar16 >> 0x10);
        local_177c = (undefined1)((uint)uVar16 >> 0x18);
        local_1780 = local_10d0;
        goto joined_r0x007afaec;
      }
      uVar15 = param_2[0x176];
      uVar11 = param_2[0x177];
    } while (uVar15 - uVar11 != iVar22);
    FUN_015e79d4(&local_1780,0x25,"early eof",9);
joined_r0x007afaec:
    if (local_1780 == 5) {
LAB_007afaf0:
      *param_1 = 3;
      *(undefined1 *)((int)param_2 + 0x5c6) = 4;
      return;
    }
    uVar11 = CONCAT13(uStack_177d,CONCAT12(uStack_177e,CONCAT11(bStack_177f,local_1780)));
joined_r0x007af9bc:
    if (local_1780 != 4) {
      puVar21 = (undefined2 *)CONCAT13((undefined1)uStack_1779,CONCAT21(uStack_177b,local_177c));
      goto LAB_007af9c8;
    }
    FUN_016dd606(&local_2240,0,0x5a);
    iVar22 = 4;
    if (1 < *param_2) {
      iVar22 = *param_2 - 2;
    }
    puVar9 = param_2 + 0x137;
    *param_2 = 7;
    if (iVar22 == 1) {
      FUN_016dd1aa(&local_12b8,local_2244,0xe0);
      uStack_10c9._1_3_ = 2;
      uStack_10c5 = uStack_10c5 & 0xffffff00;
      local_10b8 = DAT_018da5fc;
      if (DAT_018dd947 == '\0') {
        local_2b8 = DAT_018da5fc + 0x1c;
        local_2c0 = 4;
        local_2bc = (char *)0x0;
        FUN_01694880(&local_10d0,&local_2c0);
      }
      local_2c0 = CONCAT13(uStack_10cd,CONCAT12(uStack_10ce,CONCAT11(bStack_10cf,local_10d0)));
      local_2bc = (char *)CONCAT13((undefined1)uStack_10c9,CONCAT12(uStack_10ca,local_10cc));
      local_2b8 = CONCAT13((undefined1)uStack_10c5,uStack_10c9._1_3_);
      local_2b4 = CONCAT13(uStack_10c1,uStack_10c5._1_3_);
      local_2b0 = local_10c0;
      local_2ac = local_10bc;
      iStack_2a8 = local_10b8;
      uStack_2a4 = uStack_10b4;
      if (local_2b8 != 2) {
        iVar22 = local_2b4;
        if ((uStack_10c9._1_3_ & 1) != 0) {
          iVar22 = local_2b4 + (*(int *)(local_10c0 + 8) - 1U & 0xfffffff8) + 8;
        }
        (**(code **)(local_10c0 + 0x30))(iVar22,&local_2c0);
      }
      local_a80 = (undefined2)local_2c0;
      uStack_a7e = (undefined2)(local_2c0 >> 0x10);
      local_a7c = SUB42(local_2bc,0);
      uStack_a7a = (undefined2)((uint)local_2bc >> 0x10);
      local_a78 = (undefined2)local_2b8;
      uStack_a76 = (undefined2)(local_2b8 >> 0x10);
      local_a74 = local_2b4;
      local_a70 = local_2b0;
      local_a6c = local_2ac;
      local_a68 = iStack_2a8;
      local_a64 = uStack_2a4;
      local_780 = local_12b8;
      local_77c = uStack_12b4;
      local_778 = uStack_12b0;
      local_774 = uStack_12ac;
      local_770 = local_12a8;
      local_76c = uStack_12a4;
      local_768 = uStack_12a0;
      local_764 = uStack_129c;
      FUN_01110994(&local_2c0,&local_780,puVar9,0x40);
      FUN_01110994(&local_10d0,&local_2c0,param_2 + 0x147,0xaa);
                    /* WARNING: Subroutine does not return */
      FUN_00faa36c(0,0xaa,0x5a,&DAT_0185b91c);
    }
    if (iVar22 != 2) {
                    /* WARNING: Subroutine does not return */
      FUN_00faa464("not implemented",0xf,&DAT_0185b90c);
    }
    FUN_016dd1aa(&local_11d8,local_2244,0xe0);
    uStack_10c9._1_3_ = 2;
    uStack_10c5 = uStack_10c5 & 0xffffff00;
    local_10b8 = DAT_018da608;
    if (DAT_018dd947 == '\0') {
      local_2b8 = DAT_018da608 + 0x1c;
      local_2c0 = 4;
      local_2bc = (char *)0x0;
      FUN_01694880(&local_10d0,&local_2c0);
    }
    local_2c0 = CONCAT13(uStack_10cd,CONCAT12(uStack_10ce,CONCAT11(bStack_10cf,local_10d0)));
    local_2bc = (char *)CONCAT13((undefined1)uStack_10c9,CONCAT12(uStack_10ca,local_10cc));
    local_2b8 = CONCAT13((undefined1)uStack_10c5,uStack_10c9._1_3_);
    local_2b4 = CONCAT13(uStack_10c1,uStack_10c5._1_3_);
    local_2b0 = local_10c0;
    local_2ac = local_10bc;
    iStack_2a8 = local_10b8;
    uStack_2a4 = uStack_10b4;
    if (local_2b8 != 2) {
      iVar22 = local_2b4;
      if ((uStack_10c9._1_3_ & 1) != 0) {
        iVar22 = local_2b4 + (*(int *)(local_10c0 + 8) - 1U & 0xfffffff8) + 8;
      }
      (**(code **)(local_10c0 + 0x30))(iVar22,&local_2c0);
    }
    local_10f8 = local_2c0;
    uStack_10f4 = local_2bc;
    iStack_10f0 = local_2b8;
    iStack_10ec = local_2b4;
    iStack_10e8 = local_2b0;
    uStack_10e4 = local_2ac;
    iStack_10e0 = iStack_2a8;
    uStack_10dc = uStack_2a4;
    local_c00 = local_11d8;
    uStack_bfc = uStack_11d4;
    uStack_bf8 = uStack_11d0;
    uStack_bf4 = uStack_11cc;
    local_bf0 = local_11c8;
    uStack_bec = uStack_11c4;
    uStack_be8 = uStack_11c0;
    uStack_be4 = uStack_11bc;
    local_be0 = local_11b8;
    uStack_bdc = uStack_11b4;
    uStack_bd8 = uStack_11b0;
    uStack_bd4 = uStack_11ac;
    local_bd0 = local_11a8;
    uStack_bcc = uStack_11a4;
    uStack_bc8 = uStack_11a0;
    uStack_bc4 = uStack_119c;
    FUN_016dd1aa(&local_bc0,auStack_1198,0xa0);
    local_b20 = *puVar9;
    uStack_b1c = param_2[0x138];
    uStack_b18 = param_2[0x139];
    uStack_b14 = param_2[0x13a];
    uStack_b10 = param_2[0x13b];
    local_b0c = param_2[0x13c];
    uStack_b08 = param_2[0x13d];
    uStack_b04 = param_2[0x13e];
    uStack_b00 = param_2[0x13f];
    uStack_afc = param_2[0x140];
    local_af8 = param_2[0x141];
    uStack_af4 = param_2[0x142];
    uStack_af0 = param_2[0x143];
    uStack_aec = param_2[0x144];
    uStack_ae8 = param_2[0x145];
    uStack_ae4 = param_2[0x146];
    FUN_01110994(auStack_ae0,&local_c00,puVar9,0x40);
    local_2c0 = local_b80;
    local_2bc = pcStack_b7c;
    local_2b8 = uStack_b78;
    local_2b4 = uStack_b74;
    local_2b0 = iStack_b70;
    local_2ac = local_b6c;
    iStack_2a8 = iStack_b68;
    uStack_2a4 = uStack_b64;
    local_2a0 = uStack_b60;
    local_29c = uStack_b5c;
    local_298 = local_b58;
    uStack_294 = uStack_b54;
    local_290 = uStack_b50;
    local_28c = uStack_b4c;
    local_288 = uStack_b48;
    local_284 = uStack_b44;
    local_a80 = (undefined2)local_b40;
    uStack_a7e = (undefined2)((uint)local_b40 >> 0x10);
    local_a7c = (undefined2)uStack_b3c;
    uStack_a7a = (undefined2)((uint)uStack_b3c >> 0x10);
    local_a78 = (undefined2)uStack_b38;
    uStack_a76 = (undefined2)((uint)uStack_b38 >> 0x10);
    local_a74 = uStack_b34;
    local_a70 = local_b30;
    local_a6c = uStack_b2c;
    local_a68 = uStack_b28;
    local_a64 = uStack_b24;
    local_780 = 0;
    local_77c = 0;
    local_778 = 0;
    local_774 = 0;
    local_770 = 0;
    local_76c = 0;
    local_768 = 0;
    local_764 = 0;
    FUN_01834764(DAT_018db708,&local_780,&local_2c0,&local_b20,&local_a80,0,FUN_01828580,0);
    local_ac0 = local_780;
    uStack_abc = local_77c;
    uStack_ab8 = local_778;
    uStack_ab4 = local_774;
    local_ab0 = local_770;
    uStack_aac = local_76c;
    uStack_aa8 = local_768;
    uStack_aa4 = local_764;
    FUN_011105ec(&local_2c0,&local_be0,&local_ac0,0x20);
    uVar7 = local_284;
    uVar6 = local_288;
    uVar4 = local_28c;
    uVar17 = local_290;
    uVar24 = uStack_294;
    uVar23 = local_298;
    uVar15 = local_29c;
    uVar11 = local_2a0;
    local_aa0 = local_2c0;
    pcStack_a9c = local_2bc;
    uStack_a98 = local_2b8;
    uStack_a94 = local_2b4;
    local_a90 = local_2b0;
    uStack_a8c = local_2ac;
    iStack_a88 = iStack_2a8;
    uStack_a84 = uStack_2a4;
    DataMemoryBarrier(0xb);
    if (DAT_018dd942 != '\x02') {
      FUN_01110ec4();
    }
    local_a80 = 1;
    uStack_a7e = 0;
    local_a7c = (undefined2)uVar11;
    uStack_a7a = (undefined2)(uVar11 >> 0x10);
    local_a74 = uVar23;
    local_a70 = uVar24;
    local_a6c = uVar17;
    local_a68 = uVar4;
    local_a78 = (undefined2)uVar15;
    uStack_a76 = (undefined2)(uVar15 >> 0x10);
    local_a64 = uVar6;
    local_870 = &DAT_018aa88c;
    local_a60 = uVar7;
    FUN_016dd1aa(&local_850,param_2 + 0x147,0x50);
    local_860 = 1;
    local_70 = param_2[0x157];
    local_6c = (char *)param_2[0x158];
    local_68 = param_2[0x159];
    local_64 = param_2[0x15a];
    local_85c = 0;
    local_90 = 0;
    local_8c = 0;
    local_88 = 0;
    DataMemoryBarrier(0xb);
    if (DAT_018dd942 != '\x02') {
      FUN_01110ec4();
    }
    FUN_014f3308(&local_2c0,&local_a80,&local_90,auStack_ae0,0x20,&local_850,0x40,0);
    if ((char)local_2c0 == '\x01') {
LAB_007afcd4:
      uStack_10c1 = 0;
      uStack_10c9 = 0x38994d00;
      uStack_10c5 = 0x1100;
LAB_007afcf0:
      uStack_10ca = 0;
      local_10cc = 0;
      local_10d2 = 0;
      puVar19 = (undefined4 *)*puVar8;
      uVar15 = puVar8[1];
      local_10d4 = 0;
      uStack_21de = 0;
      local_21e0 = 0;
      uStack_21dd = uStack_10c9;
      puStack_21d9 = puVar19;
      local_21d5 = (byte)uVar15;
      FUN_0110d7bc(&local_10f8);
      uVar11 = CONCAT13((undefined1)uStack_21dd,CONCAT12(uStack_21de,local_21e0));
      puVar21 = (undefined2 *)CONCAT13(puStack_21d9._0_1_,uStack_21dd._1_3_);
      if (uVar11 == 6) {
        uVar15 = *param_2;
        iVar22 = 4;
        local_2264 = (undefined4 *)param_2[3];
        uVar23 = 3;
        if (1 < uVar15) {
          iVar22 = uVar15 - 2;
        }
        if (iVar22 == 4) {
          uVar11 = *local_2244;
          local_2268 = (undefined2 *)param_2[2];
          if (uVar15 != 2) {
            bVar1 = (byte)param_2[0x120];
            puVar13 = (undefined4 *)param_2[4];
            uVar24 = uVar11;
            goto LAB_007b0150;
          }
          puVar19 = local_2264;
          puVar21 = local_2268;
        }
        else {
          puVar21 = (undefined2 *)0x0;
          if (iVar22 == 5) {
            uVar11 = 4;
          }
          else {
            uVar11 = 5;
          }
        }
      }
      else {
        puVar19 = (undefined4 *)((uint)puVar19 >> 8 | (uint)(byte)uVar15 << 0x18);
        uVar23 = 3;
      }
      goto LAB_007af9cc;
    }
    local_780 = CONCAT13(local_2bc._0_1_,local_2c0._1_3_);
    local_77c = CONCAT13((undefined1)local_2b8,local_2bc._1_3_);
    local_778 = CONCAT13((undefined1)local_2b4,local_2b8._1_3_);
    local_774 = CONCAT13((undefined1)local_2b0,local_2b4._1_3_);
    iVar22 = FUN_01837f38(&local_780,&local_70,0x10);
    if (iVar22 != 0) {
      FUN_016dd606(&local_850,0,0x40);
      goto LAB_007afcd4;
    }
    FUN_01110994(auStack_800,auStack_ae0,param_2 + 0x147,0x50);
    local_7e0 = local_850;
    uStack_7dc = uStack_84c;
    uStack_7d8 = uStack_848;
    uStack_7d4 = uStack_844;
    uStack_7d0 = uStack_840;
    local_7cc = local_83c;
    uStack_7c8 = uStack_838;
    uStack_7c4 = uStack_834;
    uStack_7c0 = uStack_830;
    uStack_7bc = uStack_82c;
    local_7b8 = local_828;
    uStack_7b4 = uStack_824;
    uStack_7b0 = uStack_820;
    uStack_7ac = uStack_81c;
    uStack_7a8 = uStack_818;
    uStack_7a4 = uStack_814;
    local_780 = local_850;
    local_77c = uStack_84c;
    local_778 = uStack_848;
    local_774 = uStack_844;
    local_770 = uStack_840;
    local_76c = local_83c;
    local_768 = uStack_838;
    local_764 = uStack_834;
    local_760 = uStack_830;
    uStack_75c = uStack_82c;
    local_758 = local_828;
    uStack_754 = uStack_824;
    uStack_750 = uStack_820;
    uStack_74c = uStack_81c;
    uStack_748 = uStack_818;
    uStack_744 = uStack_814;
    local_2c0 = local_b80;
    local_2bc = pcStack_b7c;
    local_2b8 = uStack_b78;
    local_2b4 = uStack_b74;
    local_2b0 = iStack_b70;
    local_2ac = local_b6c;
    iStack_2a8 = iStack_b68;
    uStack_2a4 = uStack_b64;
    local_2a0 = uStack_b60;
    local_29c = uStack_b5c;
    local_298 = local_b58;
    uStack_294 = uStack_b54;
    local_290 = uStack_b50;
    local_28c = uStack_b4c;
    local_288 = uStack_b48;
    local_284 = uStack_b44;
    local_90 = local_b40;
    local_8c = uStack_b3c;
    local_88 = uStack_b38;
    local_84 = uStack_b34;
    local_70 = 0;
    local_6c = (char *)0x0;
    local_68 = 0;
    local_64 = 0;
    local_60 = 0;
    local_5c = 0;
    local_58 = 0;
    local_54 = 0;
    FUN_01834764(DAT_018db708,&local_70,&local_2c0,&local_780,&local_90,0,FUN_01828580,0);
    local_7a0 = local_70;
    uStack_79c = local_6c;
    uStack_798 = local_68;
    uStack_794 = local_64;
    local_790 = local_60;
    uStack_78c = local_5c;
    uStack_788 = local_58;
    uStack_784 = local_54;
    FUN_011105ec(&local_2c0,&local_aa0,&local_7a0,0x20);
    uVar7 = local_284;
    uVar6 = local_288;
    uVar4 = local_28c;
    uVar17 = local_290;
    uVar24 = uStack_294;
    uVar23 = local_298;
    uVar15 = local_29c;
    uVar11 = local_2a0;
    local_70 = local_2c0;
    local_6c = local_2bc;
    local_68 = local_2b8;
    local_64 = local_2b4;
    local_60 = local_2b0;
    local_5c = local_2ac;
    local_58 = iStack_2a8;
    local_54 = uStack_2a4;
    DataMemoryBarrier(0xb);
    if (DAT_018dd942 != '\x02') {
      FUN_01110ec4();
    }
    local_780 = 1;
    local_760 = uVar7;
    local_77c = uVar11;
    local_778 = uVar15;
    local_774 = uVar23;
    local_770 = uVar24;
    local_768 = uVar4;
    local_560 = 0;
    local_55c = 0;
    local_76c = uVar17;
    local_764 = uVar6;
    local_570 = &DAT_018aa88c;
    FUN_016dd1aa(&local_2240,param_2 + 0x15b,0x5a);
    FUN_01110994(&local_548,auStack_800,&local_2240,0x5a);
    local_560 = 1;
    local_55c = 0;
    local_4c = 0;
    local_48 = 0;
    local_44 = 0;
    local_40 = local_21f6;
    local_3c = local_21f2;
    local_38 = local_21ee;
    local_34 = local_21ea;
    DataMemoryBarrier(0xb);
    if (DAT_018dd942 != '\x02') {
      FUN_01110ec4();
    }
    FUN_014f3308(&local_2c0,&local_780,&local_4c,auStack_800,0x20,&local_2240,0x4a,0);
    if ((char)local_2c0 == '\x01') {
LAB_007b00f0:
      pcVar20 = "decryption failed";
      uVar11 = 0x11;
LAB_007b00fc:
      uStack_10c9 = (int)pcVar20 << 8;
      uStack_10c5._0_1_ = (undefined1)((uint)pcVar20 >> 0x18);
      uStack_10c5._1_3_ = (uint3)uVar11;
      uStack_10c1 = (undefined1)(uVar11 >> 0x18);
      goto LAB_007afcf0;
    }
    local_90 = CONCAT13(local_2bc._0_1_,local_2c0._1_3_);
    local_8c = CONCAT13((undefined1)local_2b8,local_2bc._1_3_);
    local_88 = CONCAT13((undefined1)local_2b4,local_2b8._1_3_);
    local_84 = CONCAT13((undefined1)local_2b0,local_2b4._1_3_);
    iVar22 = FUN_01837f38(&local_90,&local_40,0x10);
    if (iVar22 != 0) {
      FUN_016dd606(&local_2240,0,0x4a);
      goto LAB_007b00f0;
    }
    FUN_011105ec(&local_2c0,&local_70,1,0);
    local_528 = local_2c0;
    pcStack_524 = local_2bc;
    uStack_520 = local_2b8;
    uStack_51c = local_2b4;
    local_518 = local_2b0;
    uStack_514 = local_2ac;
    iStack_510 = iStack_2a8;
    uStack_50c = uStack_2a4;
    local_508 = local_2a0;
    uStack_504 = local_29c;
    uStack_500 = local_298;
    uStack_4fc = uStack_294;
    local_4f8 = local_290;
    uStack_4f4 = local_28c;
    uStack_4f0 = local_288;
    uStack_4ec = local_284;
    FUN_01110554(&local_2c0);
    uVar23 = local_2b8;
    pcVar5 = local_2bc;
    uVar15 = local_2c0;
    pcVar20 = local_2bc;
    uVar11 = local_2b8;
    if (local_2c0 == 2) goto LAB_007b00fc;
    FUN_016dd1aa(&local_4e8,(uint)&local_2c0 | 0xc,0x224);
    FUN_01110554(&local_2c0,&local_508);
    uVar11 = local_2b8;
    pcVar20 = local_2bc;
    uVar24 = local_2c0;
    if (local_2c0 == 2) goto LAB_007b00fc;
    FUN_016dd1aa(auStack_e94,(uint)&local_2c0 | 0xc,0x224);
    FUN_01110b70(auStack_c4f,&local_7e0);
    local_c70 = local_548;
    uStack_c6c = uStack_544;
    uStack_c68 = uStack_540;
    uStack_c64 = uStack_53c;
    local_c60 = local_538;
    uStack_c5c = uStack_534;
    uStack_c58 = uStack_530;
    uStack_c54 = uStack_52c;
    FUN_016dd1aa((uint)&local_10d0 | 0xc,&local_4e8,0x224);
    local_c50 = 1;
    local_ea0 = uVar24;
    local_10cc = SUB42(pcVar5,0);
    uStack_10ca = (undefined1)((uint)pcVar5 >> 0x10);
    uStack_10c9._0_1_ = (undefined1)((uint)pcVar5 >> 0x18);
    uStack_10c9._1_3_ = (uint3)uVar23;
    uVar24 = uStack_10c9;
    uStack_10c5._0_1_ = (undefined1)(uVar23 >> 0x18);
    local_e9c = pcVar20;
    local_e98 = uVar11;
    local_10d2 = uStack_10ca;
    local_10d4 = local_10cc;
    uVar23 = puVar8[1];
    uVar17 = *puVar8;
    uVar11 = puVar8[1];
    FUN_016dd1aa(auStack_13d0,(int)&local_10c0 + 3,0x111);
    FUN_016dd1aa(&local_1780,auStack_fac,0x3ac);
    local_12bc = local_10d4;
    local_12ba = local_10d2;
    FUN_0110d7bc(&local_10f8);
    *(undefined1 *)((int)param_2 + 6) = local_12ba;
    *(uint *)((int)param_2 + 0xf) = uVar11;
    *(undefined2 *)local_2244 = local_12bc;
    *(uint *)((int)param_2 + 0xb) = uVar17;
    *param_2 = uVar15;
    *(uint *)((int)param_2 + 7) = uVar24;
    FUN_016dd1aa((int)param_2 + 0x13,auStack_13d0,0x111);
    FUN_016dd1aa(param_2 + 0x49,&local_1780,0x3ac);
    local_2264 = (undefined4 *)(uVar17 >> 8 | (uint)(byte)uVar23 << 0x18);
    local_2268 = (undefined2 *)param_2[2];
    puVar21 = (undefined2 *)&DAT_0000004a;
    puVar13 = (undefined4 *)param_2[4];
    uVar24 = *local_2244;
    bVar1 = (byte)param_2[0x120];
LAB_007b0150:
    local_2244 = (uint *)(uint)bVar1;
    FUN_016dd1aa(auStack_2180,param_2 + 5,0x46c);
    FUN_016dd1aa(&local_21c0,(int)param_2 + 0x481,0x40);
    local_21d0 = *(undefined4 *)((int)param_2 + 0x4c1);
    uStack_21cc = *(undefined4 *)((int)param_2 + 0x4c5);
    uStack_21c8._0_3_ = (undefined3)*(undefined4 *)((int)param_2 + 0x4c9);
    uStack_21c8._3_1_ = (undefined1)param_2[0x133];
    uStack_21c4 = (undefined3)(param_2[0x133] >> 8);
    if ((bVar1 & 1) == 0) {
                    /* WARNING: Subroutine does not return */
      FUN_00fb74b8("BUG: remote static pubkey is missing even though handshake is finished",0x46,
                   &DAT_0185d6fc);
    }
    FUN_016dd1aa(&local_10d0,(int)param_2 + 0x481,0x40);
    local_1764 = 0;
    local_1768 = 0;
    local_176c = 0;
    local_1770 = 0;
    uStack_1771 = 0;
    uStack_1775 = 0;
    local_177c = 0;
    uStack_177b = 0;
    uStack_1779 = 0;
    local_1780 = 0;
    bStack_177f = 0;
    uStack_177e = 0;
    uStack_177d = 0;
    FUN_01832f1c(DAT_018db708,&local_1780,&local_10d0);
    local_1d10 = CONCAT13(uStack_177d,CONCAT12(uStack_177e,CONCAT11(bStack_177f,local_1780)));
    pcStack_1d0c = (char *)CONCAT13((undefined1)uStack_1779,CONCAT21(uStack_177b,local_177c));
    uStack_1d08 = CONCAT13((undefined1)uStack_1775,uStack_1779._1_3_);
    uStack_1d04 = CONCAT13(uStack_1771,uStack_1775._1_3_);
    local_2b0 = local_1770;
    local_2ac = local_176c;
    iStack_2a8 = local_1768;
    uStack_2a4 = local_1764;
    local_1d00 = local_1770;
    uStack_1cfc = local_176c;
    iStack_1cf8 = local_1768;
    uStack_1cf4 = local_1764;
    local_2c0 = local_1d10;
    local_2bc = pcStack_1d0c;
    local_2b8 = uStack_1d08;
    local_2b4 = uStack_1d04;
    if (&DAT_0000005a < puVar21) {
                    /* WARNING: Subroutine does not return */
      FUN_00faa36c(0,puVar21,0x5a,&DAT_0185d70c);
    }
    if (puVar21 < &DAT_0000004a) {
      local_10d0 = (byte)&local_1780;
      bStack_10cf = (byte)((uint)&local_1780 >> 8);
      uStack_10ce = (undefined1)((uint)&local_1780 >> 0x10);
      uStack_10cd = (undefined1)((uint)&local_1780 >> 0x18);
      local_1780 = (byte)puVar21;
      bStack_177f = (byte)((uint)puVar21 >> 8);
      uStack_177e = (undefined1)((uint)puVar21 >> 0x10);
      uStack_177d = (undefined1)((uint)puVar21 >> 0x18);
      local_10cc = 0xc484;
      uStack_10ca = 0xfa;
      uStack_10c9 = uStack_10c9 & 0xffffff00;
                    /* WARNING: Subroutine does not return */
      FUN_00faa478(&DAT_00583608,&local_10d0,&DAT_018876d8);
    }
    FUN_016dd1aa(&local_1cf0,auStack_2236,0x40);
    puVar21 = (undefined2 *)&UNK_0033e4d2;
    local_1cb0 = local_1d10;
    pcStack_1cac = pcStack_1d0c;
    uStack_1ca8 = uStack_1d08;
    uStack_1ca4 = uStack_1d04;
    uVar11 = 6;
    local_1ca0 = local_1d00;
    uStack_1c9c = uStack_1cfc;
    iStack_1c98 = iStack_1cf8;
    uStack_1c94 = uStack_1cf4;
    uVar17 = param_2[0x135];
    puVar19 = (undefined4 *)&DAT_00000015;
    uVar23 = 5;
    if (*(char *)(uVar17 + 0x10) != '\x01') goto LAB_007af9cc;
    uStack_a7a = (undefined2)local_223a;
    local_a78 = (undefined2)((uint)local_223a >> 0x10);
    uStack_a7e = (undefined2)local_223e;
    local_a7c = (undefined2)((uint)local_223e >> 0x10);
    local_a80 = local_2240;
    FUN_016dd1aa(&uStack_a76,&local_1d10,0x20);
    local_2270 = 0x80;
    FUN_016dd606(&local_1780,0,0x80);
    local_1700 = 0x6a09e667;
    uStack_16fc = 0xbb67ae85;
    uStack_16f8 = 0x3c6ef372;
    uStack_16f4 = 0xa54ff53a;
    uStack_16f0 = 0x510e527f;
    local_16ec = 0x9b05688c;
    uStack_16e8 = 0x1f83d9ab;
    uStack_16e4 = 0x5be0cd19;
    uStack_16e0 = 0;
    uStack_16dc = 0;
    local_16d8 = 0;
    uStack_16d4 = 0;
    uStack_16d0 = 0;
    uStack_16cc = 0;
    uStack_16c8 = 0;
    uStack_16c4 = 0;
    local_16bc = 0;
    local_16c0 = 0;
    local_16b0 = 0;
    local_16b8 = &DAT_018ab800;
    FUN_014f29bc(&local_1780,&local_a80,0x2a);
    FUN_016dd1aa(&local_10d0,&local_1780,0xd8);
    uVar11 = *(uint *)(local_1008 + 0x50);
    FUN_016dd1aa(&local_2c0,&local_1700,0x50);
    if (0x80 < uVar11) {
      puVar18 = &DAT_018a6dd0;
LAB_007b0974:
                    /* WARNING: Subroutine does not return */
      FUN_00faa36c(0,uVar11,local_2270,puVar18);
    }
    FUN_014f2c6c(&local_780,&local_2c0,&local_10d0,uVar11,local_1000);
    uVar11 = *(uint *)(local_780 + 0x48);
    if (0x40 < uVar11) {
      local_2270 = 0x40;
      puVar18 = &DAT_018ab870;
      goto LAB_007b0974;
    }
    if (uVar11 != 0x20) {
                    /* WARNING: Subroutine does not return */
      FUN_00fb74f8("BUG: Hash should be 32 bytes arrayBroken certificateSystem time is invalidCertificate is not yet validCertificate is no more validSignature is invalidPublic key is invalidii_stratum_proxy::translationopen/protocols/stratum-proxy/src/translation.rs"
                   ,0x22,&local_10d0,&DAT_018876f8,&DAT_018876e8);
    }
    local_4e8 = local_77c;
    uStack_4e4 = local_778;
    uStack_4e0 = local_774;
    local_4dc = local_770;
    local_4d8 = local_76c;
    uStack_4d4 = local_768;
    uStack_4d0 = local_764;
    uStack_4cc = local_760;
    local_2c0 = local_1cf0;
    local_2bc = pcStack_1cec;
    local_2b8 = uStack_1ce8;
    local_2b4 = uStack_1ce4;
    local_2b0 = iStack_1ce0;
    local_2ac = local_1cdc;
    iStack_2a8 = iStack_1cd8;
    uStack_2a4 = uStack_1cd4;
    local_2a0 = uStack_1cd0;
    local_29c = uStack_1ccc;
    local_298 = local_1cc8;
    uStack_294 = uStack_1cc4;
    local_290 = uStack_1cc0;
    local_28c = uStack_1cbc;
    local_288 = uStack_1cb8;
    local_284 = uStack_1cb4;
    FUN_016dd606(&local_10d0,0,0x40);
    iVar22 = FUN_01832c64(DAT_018db708,&local_10d0,uVar17 + 0x11);
    uVar4 = uStack_10c5;
    uVar11 = uStack_10c9;
    uVar3 = local_10cc;
    uVar2 = uStack_10cd;
    if (iVar22 != 1) {
      uVar11 = 5;
LAB_007b0708:
      puVar19 = (undefined4 *)&DAT_00000015;
      goto LAB_007af9cc;
    }
    uStack_177e = uStack_10ce;
    local_1780 = local_10d0;
    bStack_177f = bStack_10cf;
    uVar16 = CONCAT13(uStack_10ca,CONCAT21(local_10cc,uStack_10cd));
    FUN_016dd1aa(&uStack_1771,&uStack_10c1,0x31);
    uStack_1775 = uVar4;
    uStack_1779 = uVar11;
    uStack_177d = uVar2;
    local_177c = (undefined1)uVar3;
    uStack_177b = (undefined2)((uint)uVar16 >> 0x10);
    DataMemoryBarrier(0xb);
    if (DAT_018d9128 != 0) {
      local_780 = CONCAT31(local_780._1_3_,1);
      local_10d0 = (byte)&local_780;
      bStack_10cf = (byte)((uint)&local_780 >> 8);
      uStack_10ce = (undefined1)((uint)&local_780 >> 0x10);
      uStack_10cd = (undefined1)((uint)&local_780 >> 0x18);
      FUN_015eedc4(&DAT_018d9128,0,&local_10d0,&DAT_018a9208,&DAT_018a923c);
    }
    if (DAT_018dd958 == 0) {
                    /* WARNING: Subroutine does not return */
      FUN_00faa444(&DAT_018a924c);
    }
    iVar22 = FUN_01833868(DAT_018dd958,&local_2c0,&local_4e8,0x20,&local_1780);
    uVar11 = 4;
    if (iVar22 != 1) goto LAB_007b0708;
    *(undefined4 *)(uVar17 + 8) = local_223e;
    *(undefined4 *)(uVar17 + 0xc) = local_223a;
    local_1c70 = local_1d34;
    uStack_1c6c = uStack_1d30;
    uStack_1c68 = uStack_1d2c;
    uStack_1c64 = uStack_1d28;
    local_1c60 = local_1d24;
    uStack_1c5c = uStack_1d20;
    uStack_1c58 = uStack_1d1c;
    uStack_1c54 = uStack_1d18;
    local_1c90 = local_1cb0;
    pcStack_1c8c = pcStack_1cac;
    uStack_1c88 = uStack_1ca8;
    uStack_1c84 = uStack_1ca4;
    local_1c80 = local_1ca0;
    uStack_1c7c = uStack_1c9c;
    iStack_1c78 = iStack_1c98;
    uStack_1c74 = uStack_1c94;
    local_10d0 = (byte)uVar24;
    bStack_10cf = (byte)(uVar24 >> 8);
    uStack_10ce = (undefined1)(uVar24 >> 0x10);
    uStack_10cd = (undefined1)(uVar24 >> 0x18);
    local_10cc = SUB42(local_2268,0);
    uStack_10ca = (undefined1)((uint)local_2268 >> 0x10);
    uStack_10c9._0_1_ = (undefined1)((uint)local_2268 >> 0x18);
    uStack_10c9._1_3_ = (uint3)local_2264;
    uStack_10c5._0_1_ = (undefined1)((uint)local_2264 >> 0x18);
    FUN_016dd1aa(auStack_1bf0,auStack_2180,0x46c);
    local_1c30 = local_21c0;
    uStack_1c2c = uStack_21bc;
    uStack_1c28 = uStack_21b8;
    uStack_1c24 = uStack_21b4;
    uStack_1c20 = uStack_21b0;
    local_1c1c = local_21ac;
    uStack_1c18 = uStack_21a8;
    uStack_1c14 = uStack_21a4;
    uStack_1c10 = uStack_21a0;
    uStack_1c0c = uStack_219c;
    local_1c08 = local_2198;
    uStack_1c04 = uStack_2194;
    uStack_1c00 = uStack_2190;
    uStack_1bfc = uStack_218c;
    uStack_1bf8 = uStack_2188;
    uStack_1bf4 = uStack_2184;
    uStack_1c34 = uStack_21c4;
    local_1c40 = local_21d0;
    uStack_1c3c = uStack_21cc;
    uStack_1c38 = uStack_21c8;
    local_1c50 = 0;
    local_1c4c = 0;
    local_1c48 = 0;
    local_1c44 = 0;
    uVar11 = CONCAT13((undefined1)uStack_10c9,CONCAT12(uStack_10ca,local_10cc));
    puVar21 = (undefined2 *)CONCAT13((undefined1)uStack_10c5,uStack_10c9._1_3_);
    piVar12 = (int *)param_2[0x135];
    DataMemoryBarrier(0xb);
    do {
      iVar22 = *piVar12;
      bVar25 = (bool)hasExclusiveAccess(piVar12);
    } while (!bVar25);
    *piVar12 = iVar22 + -1;
    local_2244._0_1_ = bVar1;
    if (iVar22 != 1) goto LAB_007afa10;
    goto LAB_007af9fc;
  }
  puVar19 = (undefined4 *)&DAT_00000001;
  do {
    if (uVar11 == 0) {
      uVar15 = 0xea;
      uVar11 = 0;
      param_2[0x174] = (uint)(param_2 + 0x134);
      param_2[0x175] = (uint)(param_2 + 0x137);
      param_2[0x176] = 0xea;
      param_2[0x177] = 0;
      param_2[0x178] = 0xea;
      goto LAB_007af490;
    }
    FUN_01642b4c(&local_10d0,*(undefined4 *)param_2[0x174],param_3,param_2[0x175],uVar11);
    uVar15 = (uint)local_10d0;
    if (uVar15 == 5) {
      *param_1 = 3;
      *(undefined1 *)((int)param_2 + 0x5c6) = 3;
      return;
    }
    puVar21 = (undefined2 *)CONCAT13((undefined1)uStack_10c9,CONCAT12(uStack_10ca,local_10cc));
    if (uVar15 != 4) {
      uVar11 = (uint)CONCAT11(uStack_10cd,uStack_10ce) << 0x10;
      uVar23 = (uint)bStack_10cf << 8;
      goto LAB_007af998;
    }
    puVar10 = (undefined2 *)param_2[0x176];
    uVar15 = param_2[0x175];
    param_2[0x175] = 1;
    param_2[0x176] = 0;
    if (puVar10 < puVar21) {
                    /* WARNING: Subroutine does not return */
      FUN_00faa478(&DAT_00418e0f,0x13,&DAT_018a54b8);
    }
    uVar11 = (int)puVar10 - (int)puVar21;
    puVar14 = (undefined1 *)(uVar15 + (int)puVar21);
    bVar25 = puVar21 != (undefined2 *)0x0;
    puVar21 = &local_10d4;
    param_2[0x175] = (uint)puVar14;
    param_2[0x176] = uVar11;
  } while (bVar25);
  uVar15 = 1;
  uVar23 = 0x1700;
  uVar11 = 0;
LAB_007af998:
  uVar11 = uVar23 | uVar15 | uVar11;
LAB_007af9c8:
  uVar23 = 2;
LAB_007af9cc:
  uVar24 = uVar23;
  puVar13 = puVar19;
  piVar12 = (int *)param_2[0x135];
  DataMemoryBarrier(0xb);
  do {
    iVar22 = *piVar12;
    bVar25 = (bool)hasExclusiveAccess(piVar12);
  } while (!bVar25);
  *piVar12 = iVar22 + -1;
  uVar15 = 2;
  if (iVar22 == 1) {
LAB_007af9fc:
    DataMemoryBarrier(0xb);
    FUN_00784894(param_2[0x135]);
  }
LAB_007afa10:
  *param_1 = uVar15;
  param_1[1] = uVar24;
  param_1[4] = (uint)puVar13;
  param_1[2] = uVar11;
  param_1[3] = (uint)puVar21;
  FUN_016dd1aa(param_1 + 5,auStack_1bf0,0x46c);
  *(byte *)(param_1 + 0x120) = (byte)local_2244;
  FUN_016dd1aa((int)param_1 + 0x481,&local_1c30,0x40);
  *(undefined4 *)((int)param_1 + 0x4c5) = uStack_1c3c;
  *(undefined4 *)((int)param_1 + 0x4c1) = local_1c40;
  *(undefined4 *)((int)param_1 + 0x4c9) = uStack_1c38;
  param_1[0x133] = CONCAT31(uStack_1c34,uStack_1c38._3_1_);
  param_1[0x134] = local_1c50;
  param_1[0x135] = local_1c4c;
  param_1[0x136] = local_1c48;
  param_1[0x137] = local_1c44;
  param_1[0x138] = local_1c70;
  param_1[0x139] = uStack_1c6c;
  param_1[0x13a] = uStack_1c68;
  param_1[0x13b] = uStack_1c64;
  param_1[0x13c] = local_1c60;
  param_1[0x13d] = uStack_1c5c;
  param_1[0x13e] = uStack_1c58;
  param_1[0x13f] = uStack_1c54;
  *(undefined2 *)((int)param_1 + 0x507) = 0x102;
  FUN_016dd1aa((int)param_1 + 0x509,&local_1c90,0x20);
  *(undefined1 *)((int)param_2 + 0x5c6) = 1;
  return;
}

