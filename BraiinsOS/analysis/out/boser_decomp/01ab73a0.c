// FUN_01ab73a0 @ 01ab73a0 size=2920 calls_out=18 calls_in=2
// strings: 

void FUN_01ab73a0(int *param_1)

{
  char cVar1;
  undefined1 uVar2;
  uint uVar3;
  undefined4 *puVar4;
  undefined4 *puVar5;
  undefined1 uVar6;
  int *piVar7;
  int *piVar8;
  undefined4 uVar9;
  undefined4 *puVar10;
  int iVar11;
  undefined4 *puVar12;
  uint *puVar13;
  undefined8 uVar14;
  int local_1030;
  int local_1028;
  int local_1024;
  uint local_101c;
  uint local_1018;
  int *local_1014;
  int **local_1010;
  int local_100c;
  undefined4 *local_1004;
  undefined4 *local_1000;
  undefined4 *local_ffc;
  undefined4 *local_ff8;
  int local_fe8 [2];
  undefined4 local_fe0;
  undefined4 local_fdc;
  int local_fd8;
  undefined4 local_fd4;
  undefined4 local_fd0;
  int local_fcc;
  undefined4 local_fc8;
  undefined4 local_fc4;
  undefined4 local_fc0;
  char local_fb4;
  undefined4 local_fb0;
  undefined2 local_fac;
  undefined1 auStack_fa8 [336];
  undefined1 auStack_e58 [224];
  undefined1 auStack_d78 [128];
  undefined4 *local_cf8;
  undefined4 *puStack_cf4;
  uint uStack_cf0;
  int iStack_cec;
  undefined4 *puStack_ce8;
  undefined2 local_ce4;
  undefined1 local_ce2;
  undefined4 *local_ce0;
  undefined4 *puStack_cdc;
  uint uStack_cd8;
  int iStack_cd4;
  undefined4 *local_cd0;
  undefined4 *puStack_ccc;
  uint uStack_cc8;
  int **ppiStack_cc4;
  int *piStack_cc0;
  int *local_cbc;
  int local_cb8 [2];
  undefined4 *local_cb0;
  undefined4 *local_cac;
  undefined4 *puStack_ca8;
  uint uStack_ca4;
  int iStack_ca0;
  undefined4 *local_c9c;
  undefined4 *local_c98;
  uint uStack_c94;
  int **local_c90;
  int *local_c8c;
  undefined4 *local_c38;
  undefined4 *puStack_c34;
  uint uStack_c30;
  int iStack_c2c;
  undefined4 *puStack_c28;
  undefined2 local_c24;
  undefined1 local_c22;
  undefined4 *local_c20;
  undefined4 *puStack_c1c;
  uint uStack_c18;
  int iStack_c14;
  undefined4 *local_c10;
  undefined4 local_c0c;
  uint uStack_c08;
  int **ppiStack_c04;
  int *piStack_c00;
  int local_bf8;
  int iStack_bf4;
  int iStack_bf0;
  int iStack_bec;
  int iStack_be8;
  int local_be4;
  int iStack_be0;
  int iStack_bdc;
  int iStack_bd8;
  int iStack_bd4;
  int local_bd0;
  int iStack_bcc;
  int iStack_bc8;
  int iStack_bc4;
  int iStack_bc0;
  int local_bbc;
  int iStack_bb8;
  int iStack_bb4;
  int iStack_bb0;
  int iStack_bac;
  uint local_ba8;
  int *local_ba4;
  uint local_ba0;
  undefined4 local_b9c;
  undefined4 local_b98;
  undefined4 local_b94;
  uint local_b90;
  int *local_b8c;
  uint local_b88;
  undefined1 auStack_a50 [224];
  undefined4 local_970;
  undefined2 local_96c;
  uint local_968;
  int *local_964;
  uint local_960;
  uint local_95c;
  int local_818;
  undefined4 *local_814;
  undefined4 *local_810;
  undefined1 auStack_738 [128];
  undefined4 *local_6b8;
  undefined4 *puStack_6b4;
  uint uStack_6b0;
  int iStack_6ac;
  undefined4 *puStack_6a8;
  undefined2 local_6a4;
  undefined1 local_6a2;
  undefined4 *local_6a0;
  undefined4 *puStack_69c;
  uint uStack_698;
  int iStack_694;
  undefined4 *local_690;
  undefined4 *puStack_68c;
  uint uStack_688;
  int **ppiStack_684;
  int *piStack_680;
  int local_678;
  undefined4 *local_674;
  undefined4 *local_670;
  undefined4 *local_66c;
  undefined4 *local_668;
  uint local_664;
  int local_660;
  undefined4 *local_65c;
  undefined4 *local_658;
  uint local_654;
  int **local_650;
  int *local_64c;
  int local_648;
  int local_644;
  undefined1 local_640;
  undefined1 auStack_63f [23];
  uint local_628;
  uint local_624;
  int **local_620;
  int *local_61c;
  undefined1 auStack_618 [128];
  int local_598;
  undefined4 *local_594;
  int local_590 [55];
  undefined4 *local_4b4;
  int local_4b0;
  undefined1 auStack_4ac [332];
  undefined1 local_360;
  char local_35f;
  undefined4 local_35e;
  undefined2 local_35a;
  int local_358;
  undefined4 *local_354;
  undefined4 *local_350;
  undefined4 *local_34c;
  undefined4 *puStack_348;
  uint uStack_344;
  int local_340;
  undefined4 *local_33c;
  undefined4 *puStack_338;
  uint uStack_334;
  int **ppiStack_330;
  int *piStack_32c;
  int local_328;
  int local_324;
  undefined1 local_320;
  undefined1 auStack_31f [23];
  uint local_308;
  uint local_304;
  int **local_300;
  int *local_2fc;
  undefined1 auStack_2f8 [128];
  int local_278;
  undefined4 *local_274;
  undefined1 auStack_270 [92];
  undefined4 *local_214;
  int local_20c;
  undefined4 *local_208;
  undefined1 auStack_204 [112];
  undefined4 *local_194;
  int local_190;
  undefined1 auStack_18c [100];
  undefined4 *local_128;
  int local_124;
  undefined1 local_40;
  char local_3f;
  undefined4 local_3e;
  undefined2 local_3a;
  undefined4 *local_38;
  uint uStack_34;
  int iStack_30;
  
  local_fc0 = 0x80000000;
  local_fb4 = '\x01';
  local_fe8[0] = 6;
  FUN_019abc84(&local_358,&DAT_00570ff8,8);
  puVar5 = local_350;
  puVar4 = local_354;
  if (local_358 == 1) {
    param_1[3] = (int)local_34c;
    param_1[0x38] = 2;
    *param_1 = 1;
    param_1[1] = (int)local_354;
    param_1[2] = (int)local_350;
    goto LAB_01ab7bb4;
  }
  local_cbc = local_fe8;
  if (local_34c == (undefined4 *)0x0) {
    FUN_01abe70c(&local_358);
    uVar2 = local_320;
    iVar11 = local_358;
    local_ff8 = local_354;
    local_ffc = local_350;
    local_ce0 = local_34c;
    puStack_cdc = puStack_348;
    uStack_cd8 = uStack_344;
    iStack_cd4 = local_340;
    local_cd0 = local_33c;
    puStack_ccc = puStack_338;
    uStack_cc8 = uStack_334;
    ppiStack_cc4 = ppiStack_330;
    piStack_cc0 = piStack_32c;
    local_1024 = local_328;
    local_1028 = local_324;
    FUN_01bed4e2(&local_cf8,auStack_31f,0x17);
    local_1018 = local_308;
    local_101c = local_304;
    local_1010 = local_300;
    local_1014 = local_2fc;
    FUN_01bed4e2(auStack_d78,auStack_2f8,0x80);
    local_1030 = local_278;
    local_1000 = local_274;
    FUN_01bed4e2(auStack_e58,auStack_270,0xdc);
    local_1004 = local_194;
    local_100c = local_190;
    FUN_01bed4e2(auStack_fa8,auStack_18c,0x14c);
    local_fb0 = local_3e;
    local_fac = local_3a;
    cVar1 = local_3f;
    uVar6 = local_40;
LAB_01ab7a70:
    FUN_0134bd64(puVar4,puVar5);
    if (local_1030 != 2) {
      param_1[1] = (int)local_ff8;
      param_1[2] = (int)local_ffc;
      *param_1 = iVar11;
      param_1[3] = (int)local_ce0;
      param_1[4] = (int)puStack_cdc;
      param_1[5] = uStack_cd8;
      param_1[6] = iStack_cd4;
      param_1[7] = (int)local_cd0;
      param_1[8] = (int)puStack_ccc;
      param_1[9] = uStack_cc8;
      param_1[10] = (int)ppiStack_cc4;
      param_1[0xb] = (int)piStack_cc0;
      *(undefined1 *)(param_1 + 0xe) = uVar2;
      param_1[0xc] = local_1024;
      param_1[0xd] = local_1028;
      FUN_01bed4e2((int)param_1 + 0x39,&local_cf8,0x17);
      param_1[0x14] = local_1018;
      param_1[0x15] = local_101c;
      param_1[0x16] = (int)local_1010;
      param_1[0x17] = (int)local_1014;
      FUN_01bed4e2(param_1 + 0x18,auStack_d78,0x80);
      param_1[0x38] = local_1030;
      param_1[0x39] = (int)local_1000;
      FUN_01bed4e2(param_1 + 0x3a,auStack_e58,0xdc);
      param_1[0x71] = (int)local_1004;
      param_1[0x72] = local_100c;
      FUN_01bed4e2(param_1 + 0x73,auStack_fa8,0x14c);
      *(undefined4 *)((int)param_1 + 0x31a) = local_fb0;
      *(char *)((int)param_1 + 0x319) = cVar1;
      *(undefined1 *)(param_1 + 0xc6) = uVar6;
      *(undefined2 *)((int)param_1 + 0x31e) = local_fac;
      goto LAB_01ab7bb4;
    }
  }
  else {
    local_818 = 3;
    local_64c = &local_818;
    local_650 = &local_cbc;
    local_654 = CONCAT22(local_654._2_2_,1);
    local_660 = CONCAT31(local_660._1_3_,1);
    local_658 = local_34c;
    local_65c = (undefined4 *)0x0;
    local_664 = 0x2c;
    local_668 = local_34c;
    local_66c = (undefined4 *)0x0;
    local_670 = local_34c;
    local_674 = local_350;
    local_678 = 0x2c;
    FUN_01abd2c8(&local_bf8,&local_678);
    if (local_bf8 == 6) {
      local_b88 = 0;
      local_b8c = (int *)&SUB_00000004;
      local_b90 = 0;
    }
    else {
      piVar7 = (int *)FUN_01298504(0xa0,4);
      if (piVar7 == (int *)0x0) {
                    /* WARNING: Subroutine does not return */
        FUN_00664620(4,0xa0);
      }
      *piVar7 = local_bf8;
      piVar7[1] = iStack_bf4;
      piVar7[2] = iStack_bf0;
      piVar7[3] = iStack_bec;
      piVar7[4] = iStack_be8;
      iVar11 = 0x28;
      piVar7[5] = local_be4;
      piVar7[6] = iStack_be0;
      piVar7[7] = iStack_bdc;
      piVar7[8] = iStack_bd8;
      piVar7[9] = iStack_bd4;
      local_968 = 4;
      local_960 = 1;
      local_358 = local_678;
      local_354 = local_674;
      local_350 = local_670;
      local_34c = local_66c;
      puStack_348 = local_668;
      uStack_344 = local_664;
      local_340 = local_660;
      local_33c = local_65c;
      puStack_338 = local_658;
      uStack_334 = local_654;
      ppiStack_330 = local_650;
      piStack_32c = local_64c;
      local_964 = piVar7;
      while( true ) {
        uVar3 = local_960;
        FUN_01abd2c8(&local_bd0,&local_358);
        if (local_bd0 == 6) break;
        if (uVar3 == local_968) {
          FUN_006520b4(&local_968,uVar3,1,4,0x28);
          piVar7 = local_964;
        }
        piVar8 = (int *)((int)piVar7 + iVar11);
        local_960 = uVar3 + 1;
        iVar11 = iVar11 + 0x28;
        *piVar8 = local_bd0;
        piVar8[1] = iStack_bcc;
        piVar8[2] = iStack_bc8;
        piVar8[3] = iStack_bc4;
        piVar8[4] = iStack_bc0;
        piVar8[5] = local_bbc;
        piVar8[6] = iStack_bb8;
        piVar8[7] = iStack_bb4;
        piVar8[8] = iStack_bb0;
        piVar8[9] = iStack_bac;
      }
      local_b90 = local_968;
      local_b8c = local_964;
      local_b88 = local_960;
    }
    iVar11 = local_818;
    cVar1 = local_fb4;
    if (local_818 == 3) {
      local_ba8 = local_b90;
      local_ba0 = local_b88;
      local_ba4 = local_b8c;
      local_b94 = 0;
      local_b98 = 4;
      local_b9c = 0;
      if (local_b88 != 0) {
        piVar7 = local_b8c + 2;
        iVar11 = local_b88 * 0x28;
        do {
          if (cVar1 == '\0') {
            FUN_01ab4e64(*piVar7,piVar7[1]);
          }
          piVar7 = piVar7 + 10;
          iVar11 = iVar11 + -0x28;
        } while (iVar11 != 0);
      }
      FUN_01ab4fa4(&local_358,&local_ba8);
      puVar10 = local_354;
      iVar11 = local_358;
      FUN_01bed4e2(&local_b90,&local_350,0x13c);
      FUN_01bed4e2(auStack_a50,auStack_204,0xdc);
      local_1000 = local_208;
      local_674 = local_208;
      local_1030 = local_20c;
      local_678 = local_20c;
      FUN_01bed4e2(&local_670,auStack_a50,0xdc);
      local_100c = local_124;
      local_590[0] = local_124;
      local_1004 = local_128;
      local_594 = local_128;
      local_358 = iVar11;
      local_354 = puVar10;
      uVar9 = FUN_01bed4e2(&local_350,&local_b90,0x13c);
      uVar14 = thunk_FUN_01bee35a(uVar9,0x2c0);
      puVar13 = (uint *)((int)uVar14 + (int)((ulonglong)uVar14 >> 0x20));
      puVar12 = local_214;
      if ((undefined4 *)0x8 < local_214) {
        puVar12 = puVar10;
      }
      if ((char)puVar13[4] == '\0') {
        FUN_019ae6ac(&local_968);
        *puVar13 = local_968;
        puVar13[1] = (uint)local_964;
        puVar13[2] = local_960;
        puVar13[3] = local_95c;
        *(undefined1 *)(puVar13 + 4) = 1;
      }
      local_c98 = (undefined4 *)*puVar13;
      uStack_c94 = puVar13[1];
      local_1018 = (int)local_c98 + 1;
      local_1010 = (int **)puVar13[2];
      local_1014 = (int *)puVar13[3];
      local_101c = uStack_c94 + ((undefined4 *)0xfffffffe < local_c98);
      *puVar13 = local_1018;
      puVar13[1] = local_101c;
      local_cb0 = (undefined4 *)((uint)local_cb0 & 0xffffff00);
      local_cb8[1] = 0;
      local_cb8[0] = 0;
      puStack_ca8 = &DAT_0056d238;
      uStack_ca4 = 0;
      iStack_ca0 = 0;
      local_c9c = (undefined4 *)0x0;
      *puVar13 = (int)local_c98 + 2;
      puVar13[1] = uStack_c94 + ((undefined4 *)0xfffffffd < local_c98);
      local_c90 = local_1010;
      local_c8c = local_1014;
      FUN_01bed4e2((uint)&local_c20 | 7,&DAT_01d30848,0x10);
      FUN_01bed93e(auStack_738,0,0x80);
      cVar1 = local_fb4;
      FUN_01bed4e2(&local_818,auStack_a50,0xdc);
      FUN_01bed4e2(&local_968,&local_358,0x14c);
      iVar11 = local_fe8[0];
      local_6a0 = local_cac;
      puStack_69c = puStack_ca8;
      uStack_698 = uStack_ca4;
      iStack_694 = iStack_ca0;
      local_690 = local_c9c;
      puStack_68c = local_c98;
      uStack_688 = uStack_c94;
      ppiStack_684 = local_c90;
      piStack_680 = local_c8c;
      local_6b8 = local_c20;
      puStack_6b4 = puStack_c1c;
      uStack_6b0 = uStack_c18;
      iStack_6ac = iStack_c14;
      puStack_6a8 = local_c10;
      local_6a2 = local_c0c._2_1_;
      local_6a4 = (undefined2)local_c0c;
      if (puVar12 == (undefined4 *)0x0) {
        puVar10 = local_128;
        if ((undefined4 *)0x8 < local_128) {
          puVar10 = local_208;
        }
        uVar6 = 0;
        if ((puVar10 != (undefined4 *)0x0) || (local_fe8[0] == 6)) goto LAB_01ab7948;
        local_350 = local_cb0;
        local_354 = (undefined4 *)0x0;
        local_358 = 0;
        local_34c = local_cac;
        puStack_348 = puStack_ca8;
        uStack_344 = uStack_ca4;
        local_340 = iStack_ca0;
        local_33c = local_c9c;
        puStack_338 = local_c98;
        uStack_334 = uStack_c94;
        ppiStack_330 = local_c90;
        piStack_32c = local_c8c;
        local_320 = 0;
        local_324 = 0;
        local_328 = 0;
        FUN_01bed4e2(auStack_31f,&local_6b8,0x17);
        FUN_01bed93e(auStack_2f8,0,0x80);
        local_274 = local_208;
        local_278 = local_20c;
        FUN_01bed4e2(auStack_270,auStack_a50,0xdc);
        local_190 = local_124;
        local_194 = local_128;
        FUN_01bed4e2(auStack_18c,&local_968,0x14c);
        local_3a = local_96c;
        local_3f = cVar1;
        local_40 = 0;
        local_3e = local_970;
        if (local_fd8 == -0x80000000) {
          local_38 = (undefined4 *)0x80000000;
        }
        else {
          FUN_006666fc(&local_38,local_fd4,local_fd0);
        }
        FUN_01ab0f54(&local_c38,local_fe0,local_fdc);
        if (local_fcc == -0x80000000) {
          local_c20 = (undefined4 *)0x80000000;
        }
        else {
          FUN_006666fc(&local_c20,local_fc8,local_fc4);
        }
        puVar10 = (undefined4 *)((uint)local_cb8 | 4);
        puStack_ca8 = local_38;
        uStack_ca4 = uStack_34;
        iStack_ca0 = iStack_30;
        *puVar10 = local_c38;
        puVar10[1] = puStack_c34;
        puVar10[2] = uStack_c30;
        local_c9c = local_c20;
        local_c98 = puStack_c1c;
        uStack_c94 = uStack_c18;
        local_cb8[0] = iVar11;
        FUN_01ab6924(&local_678,&local_358,local_cb8);
        local_ffc = local_670;
        iVar11 = local_678;
        local_ff8 = local_674;
        local_6a0 = local_66c;
        puStack_69c = local_668;
        uStack_698 = local_664;
        iStack_694 = local_660;
        local_690 = local_65c;
        puStack_68c = local_658;
        uStack_688 = local_654;
        ppiStack_684 = local_650;
        piStack_680 = local_64c;
        local_1024 = local_648;
        local_1028 = local_644;
        FUN_01bed4e2(&local_6b8,auStack_63f,0x17);
        local_1018 = local_628;
        local_101c = local_624;
        local_1010 = local_620;
        local_1014 = local_61c;
        FUN_01bed4e2(auStack_738,auStack_618,0x80);
        local_1030 = local_598;
        local_1000 = local_594;
        FUN_01bed4e2(&local_818,local_590,0xdc);
        local_1004 = local_4b4;
        local_100c = local_4b0;
        FUN_01bed4e2(&local_968,auStack_4ac,0x14c);
        local_970 = local_35e;
        local_96c = local_35a;
        cVar1 = local_35f;
        uVar2 = local_640;
        uVar6 = local_360;
      }
      else {
        uVar6 = 1;
LAB_01ab7948:
        iVar11 = 0;
        local_ff8 = (undefined4 *)0x0;
        local_1024 = 0;
        local_1028 = 0;
        local_ffc = local_cb0;
        uVar2 = 0;
      }
      local_c20 = local_6a0;
      puStack_c1c = puStack_69c;
      uStack_c18 = uStack_698;
      iStack_c14 = iStack_694;
      local_c10 = local_690;
      local_c0c = puStack_68c;
      uStack_c08 = uStack_688;
      ppiStack_c04 = ppiStack_684;
      piStack_c00 = piStack_680;
      local_c38 = local_6b8;
      puStack_c34 = puStack_6b4;
      uStack_c30 = uStack_6b0;
      iStack_c2c = iStack_6ac;
      puStack_c28 = puStack_6a8;
      local_c24 = local_6a4;
      local_c22 = local_6a2;
      FUN_01bed4e2(local_cb8,auStack_738,0x80);
      FUN_01bed4e2(&local_678,&local_818,0xdc);
      FUN_01bed4e2(&local_358,&local_968,0x14c);
      FUN_01ab0b14(&local_b9c);
      local_ce0 = local_c20;
      puStack_cdc = puStack_c1c;
      uStack_cd8 = uStack_c18;
      iStack_cd4 = iStack_c14;
      local_cd0 = local_c10;
      puStack_ccc = local_c0c;
      uStack_cc8 = uStack_c08;
      ppiStack_cc4 = ppiStack_c04;
      piStack_cc0 = piStack_c00;
      local_cf8 = local_c38;
      puStack_cf4 = puStack_c34;
      uStack_cf0 = uStack_c30;
      iStack_cec = iStack_c2c;
      puStack_ce8 = puStack_c28;
      local_ce4 = local_c24;
      local_ce2 = local_c22;
      FUN_01bed4e2(auStack_d78,local_cb8,0x80);
      FUN_01bed4e2(auStack_e58,&local_678,0xdc);
      FUN_01bed4e2(auStack_fa8,&local_358,0x14c);
      local_fb0 = local_970;
      local_fac = local_96c;
      goto LAB_01ab7a70;
    }
    FUN_01ab0b14(&local_b90);
    FUN_0134bd64(puVar4,puVar5);
    local_ffc = local_810;
    local_ff8 = local_814;
  }
  param_1[0x38] = 2;
  *param_1 = 0;
  param_1[1] = iVar11;
  param_1[2] = (int)local_ff8;
  param_1[3] = (int)local_ffc;
LAB_01ab7bb4:
  FUN_01ab6c8c(local_fe8);
  return;
}

